# Repository andrastantos/anachron (continued)

## KiCad design boards/a1_mega/a1_mega.kicad_pcb (continued)

Parts:
C4, C5, C6, C7, C60, C61, C62, C63, C64, C65, C66: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C8, C9: 22pF; C_Disc_D3.4mm_W2.1mm_P2.50mm
C10: 10u; CP_Radial_D4.0mm_P2.00mm
C11, C12: 0.1uF; C_Disc_D3.4mm_W2.1mm_P2.50mm
C17, C18, C19, C20, C21, C22: 100uF; CP_Radial_D5.0mm_P2.00mm
CMC5, CMC6, CMC7, CMC8, CMC9, CMC10: L_Ferrite_Coupled_Small; SCM2012FS
FB2, FB3, FB4, FB5, FB6, FB7, FB8, FB9, FB10, FB11, FB12: FerriteBead_Small; L_Axial_L7.0mm_D3.3mm_P2.54mm_Vertical_Fastron_MICC
J7: Micro_SD_Card; GCT_MEM2052-00-195-00-A_REVA
J8, J9, J14: USB_A_Stacked; GCT_USB1035-XX-X-X-X-B_REVE
J10: DE9_Plug; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_Hou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
J11: ARJM11D7-009-AB-EW2
JP2: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
R4, R8, R9, R28: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R5, R6: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R12, R13: 220; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R14, R15, R16, R17: 49.9; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RN8: 10k; R_Array_SIP5
RN10: 10k; R_Array_SIP9
U26: MIO; DIP-40_W15.24mm_Socket
U28: MAX232; DIP-16_W7.62mm_LongPads
U29: DS1307+; DIP-8_W7.62mm; not fitted
U32: KSZ8851-11MLL; DIP-32_W15.24mm_LongPads
U34: A1_USBHUB; DIP-40_W15.24mm_Socket
X2: 24MHz; Oscillator_DIP-14
Y1: 32768Hz; Crystal_AT310_D3.0mm_L10.0mm_Horizontal_1EP_style2; not fitted
Y2: 25MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C6.1, C60.1, C61.1, C62.1, C63.1, C64.1, C65.1, C66.1, J7.4 (VDD), R4.2, R8.2, R9.2, R28.2, RN8.1 (common), RN10.1 (common), U26.40 (VCC), U28.16 (VCC), U29.8 (VCC), U32.32 (VCC), U34.15 (VCC), U34.16 (VCC), U34.17 (VCC), U34.18 (VCC), U34.19 (VCC), U34.40 (VCC), X2.1 (EN), X2.14 (Vcc); also elsewhere on the board
+BATT: U29.3 (VBAT); also elsewhere on the board
/BUF_A0: U26.31 (A0), U32.15 (CMD); also elsewhere on the board
/BUF_D0: U26.32 (D0), U32.9 (D7); also elsewhere on the board
/BUF_D1: U26.33 (D1), U32.8 (D6); also elsewhere on the board
/BUF_D2: U26.34 (D2), U32.7 (D5); also elsewhere on the board
/BUF_D3: U26.35 (D3), U32.6 (D4); also elsewhere on the board
/BUF_D4: U26.36 (D4), U32.5 (D3); also elsewhere on the board
/BUF_D5: U26.37 (D5), U32.4 (D2); also elsewhere on the board
/BUF_D6: U26.38 (D6), U32.3 (D1); also elsewhere on the board
/BUF_D7: U26.39 (D7), U32.2 (D0); also elsewhere on the board
/BUF_~WE: U26.27 (~WE), U32.14 (~WE); also elsewhere on the board
/CPU_DRQ0: U26.23 (DRQ); also elsewhere on the board
/CPU_TC: U26.25 (~DMA_TC); also elsewhere on the board
/CPU_~DACK0: U26.24 (~DACK); also elsewhere on the board
/CPU_~INT: U26.30 (~INT); also elsewhere on the board
/I2C_SCL: RN8.5 (R4), U26.14 (PA7_I2CSCL2), U29.6 (SCL), U34.28 (SCL); also elsewhere on the board
/I2C_SDA: RN8.4 (R3), U26.13 (PA6_I2CSDA2), U29.5 (SDA), U34.29 (SDA); also elsewhere on the board
/MIO/SD_CLK: J7.5 (CLK), RN10.9 (R8), U26.22 (PB5_SDclk)
/MIO/SD_CMD: J7.3 (CMD), RN10.8 (R7), U26.21 (PB4_SDcmd)
/MIO/SD_D0: J7.7 (DAT0), RN10.4 (R3), U26.15 (PB0_SDd0)
/MIO/SD_D1: J7.8 (DAT1), RN10.5 (R4), U26.16 (PB1_SDd1)
/MIO/SD_D2: J7.1 (DAT2), RN10.6 (R5), U26.17 (PB2_SDd2)
/MIO/SD_D3: J7.2 (DAT3/CD), RN10.7 (R6), U26.19 (PB3_SDd3)
/MIO/SER_CTS: R6.1, U26.10 (PA3_CTS_~SPICS)
/MIO/SER_RTS: U26.9 (PA2_RTS_SPIMOSI), U28.10 (T2IN)
/MIO/SER_RXD: R5.1, U26.8 (PA1_RXD)
/MIO/SER_TXD: U26.7 (PA0_TXD), U28.11 (T1IN)
/MIO/USB_CLK: U26.28 (USB_CLK), U34.2 (XTAL1/CLKIN), X2.8 (OUT)
/MIO/USB_D+: U26.5 (PC4_USBc_D+), U34.39 (USBUP_DP)
/MIO/USB_D-: U26.6 (PC5_USBc_D-), U34.38 (USBUP_DM)
/VIDEO_DDC_SCL: RN8.3 (R2), U26.12 (PA5_SPICLK_I2CSCL1); also elsewhere on the board
/VIDEO_DDC_SDA: RN8.2 (R1), U26.11 (PA4_SPIMISO_I2CSDA1); also elsewhere on the board
/VIDEO_HPD: U26.1 (PC0_USBa_D+); also elsewhere on the board
/~LAN_IRQ: R8.1, U32.13 (~INTR); also elsewhere on the board
/~LAN_SEL: U32.17 (~CS); also elsewhere on the board
/~LAN_WOL: R9.1, U32.12 (PME)
/~MIO_SEL: U26.26 (~CS); also elsewhere on the board
/~RTC_INT: R28.1, U26.3 (PC2_USBb_D+), U29.7 (SQW/OUT); also elsewhere on the board
GND: C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, J7.6 (VSS), J7.10 (SHIELD), J8.4 (GND1), J8.8 (GND2), J8.9 (Shield), J9.4 (GND1), J9.8 (GND2), J9.9 (Shield), J10.5, J11.R8, J11.SH, J14.4 (GND1), J14.8 (GND2), J14.9 (Shield), JP2.1 (A), U26.20 (GND), U28.15 (GND), U29.4 (GND), U32.16 (GND), U32.19 (GND), U32.20 (GND), U32.24 (GND), U32.25 (GND), U32.28 (GND), U32.31 (GND), U34.14 (GND), U34.20 (GND), U34.30 (GND), U34.31 (GND), U34.33 (CFG_SEL1), X2.7 (GND); also elsewhere on the board
unnamed: C11.1, R14.1, R15.1
unnamed: C12.1, R16.1, R17.1
unnamed: FB8.2, J10.4
unnamed: FB9.2, J10.3
unnamed: FB10.2, J10.7
unnamed: FB11.2, J10.2
unnamed: FB12.2, J10.8
unnamed: J7.9 (DET), R4.1, U26.2 (PC1_USBa_D-)
unnamed: CMC5.3, J8.3 (D1+)
unnamed: CMC5.2, J8.2 (D1-)
unnamed: CMC6.3, J8.7 (D2+)
unnamed: CMC6.2, J8.6 (D2-)
unnamed: C18.1, FB4.2, J8.1 (VBUS1)
unnamed: C17.1, FB5.2, J8.5 (VBUS2)
unnamed: CMC7.3, J9.3 (D1+)
unnamed: CMC7.2, J9.2 (D1-)
unnamed: CMC8.3, J9.7 (D2+)
unnamed: CMC8.2, J9.6 (D2-)
unnamed: C19.1, FB2.2, J9.1 (VBUS1)
unnamed: C20.1, FB3.2, J9.5 (VBUS2)
unnamed: J11.L1, R12.2
unnamed: J11.L3, R13.2
unnamed: C10.1, J11.R4 (TCT), J11.R5 (RCT), U32.22 (VDD3P3_A)
unnamed: J11.R3 (RD+), R14.2, U32.26 (RXP1)
unnamed: J11.R6 (RD-), R15.2, U32.27 (RXM1)
unnamed: J11.R1 (TD+), R16.2, U32.29 (TXP1)
unnamed: J11.R2 (TD-), R17.2, U32.30 (TXM1)
unnamed: CMC9.2, J14.3 (D1+)
unnamed: CMC9.3, J14.2 (D1-)
unnamed: CMC10.2, J14.7 (D2+)
unnamed: CMC10.3, J14.6 (D2-)
unnamed: C21.1, FB7.2, J14.1 (VBUS1)
unnamed: C22.1, FB6.2, J14.5 (VBUS2)
unnamed: JP2.2 (B), U34.13 (CFG_SEL2)
unnamed: C4.1, U28.1 (C1+)
unnamed: C4.2, U28.3 (C1-)
unnamed: C5.1, U28.4 (C2+)
unnamed: C5.2, U28.5 (C2-)
unnamed: FB11.1, U28.13 (R1IN)
unnamed: R5.2, U28.12 (R1OUT)
unnamed: FB12.1, U28.8 (R2IN)
unnamed: R6.2, U28.9 (R2OUT)
unnamed: FB9.1, U28.14 (T1OUT)
unnamed: FB10.1, U28.7 (T2OUT)
unnamed: C6.2, FB8.1, U28.2 (VS+)
unnamed: C7.1, U28.6 (VS-)
unnamed: U29.1 (X1), Y1.1
unnamed: U29.2 (X2), Y1.2
unnamed: R12.1, U32.11 (P1LED0)
unnamed: R13.1, U32.10 (P1LED1)
unnamed: J11.L2, J11.L4, U32.1 (V3P3)
unnamed: C9.1, U32.21 (XTAL1), Y2.2
unnamed: C8.1, U32.23 (XTAL2), Y2.1
unnamed: CMC7.1, U34.5 (USBDN2_DM)
unnamed: CMC7.4, U34.6 (USBDN2_DP)
unnamed: CMC8.1, U34.7 (USBDN3_DM)
unnamed: CMC8.4, U34.8 (USBDN3_DP)
unnamed: CMC5.1, U34.9 (USBDN4_DM)
unnamed: CMC5.4, U34.10 (USBDN4_DP)
unnamed: CMC6.1, U34.11 (USBDN5_DM)
unnamed: CMC6.4, U34.12 (USBDN5_DP)
unnamed: CMC10.4, U34.34 (USBDN6_DM)
unnamed: CMC10.1, U34.35 (USBDN6_DP)
unnamed: CMC9.4, U34.36 (USBDN7_DM)
unnamed: CMC9.1, U34.37 (USBDN7_DP)
unnamed: FB2.1, U34.25 (VBUS2)
unnamed: FB3.1, U34.26 (VBUS3)
unnamed: FB4.1, U34.27 (VBUS4)
unnamed: FB5.1, U34.22 (VBUS5)
unnamed: FB6.1, U34.21 (VBUS6)
unnamed: FB7.1, U34.23 (VBUS7)
SYS_CLK: U26.18 (SYS_CLK); also elsewhere on the board
~RST: U26.29 (~RST), U32.18 (~RST), U34.32 (~RST); also elsewhere on the board

Notes on the sheet:
DRQ signals must be open-SOURCE and DACK must be ignored when DRQ is not active!!!
Replaced by AtTiny MCU in power section
TODO: check connector depth!
DTR: connected to +9V for mouse support

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
Board: 4 copper layers, 243.8 x 243.8 mm, 219 parts (0 on the bottom side), 347 nets.

## KiCad design boards/a1_lan/a1_lan.kicad_pcb

Parts:
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2: BAT54; SOT-23
FB1, FB2: FerriteBead_Small; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1: 3.01k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SOCKET2: Conn_02x20_Counter_Clockwise; DIP-32_pin_header
U1: LM3480-3.3; SOT-23
U2: 74LVC04; TSSOP-14_4.4x5mm_P0.65mm
U3: 74LVC245; TSSOP-20_4.4x6.5mm_P0.65mm
U4: KSZ8851-11MLL; LQFP-48_7x7mm_P0.5mm
U5: 93CxxA; TSSOP-8_4.4x3mm_P0.65mm
U6: 74LVC1G04; SOT-23-5_HandSoldering

Connections:
+3.3V: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C13.1, FB1.1, R3.2, SOCKET2.1, U1.1 (VO), U2.14 (VCC), U3.20 (VCC), U4.27 (VDDIO), U4.38 (VDDIO), U4.46 (VDDIO), U5.6 (ORG), U5.8 (VCC), U6.5 (VCC)
+5V: C3.1, SOCKET2.32, U1.2 (VI)
/D0: SOCKET2.2, U3.2 (A0)
/D1: SOCKET2.3, U3.3 (A1)
/D2: SOCKET2.4, U3.4 (A2)
/D3: SOCKET2.5, U3.5 (A3)
/D4: SOCKET2.6, U3.6 (A4)
/D5: SOCKET2.7, U3.7 (A5)
/D6: SOCKET2.8, U3.8 (A6)
/D7: SOCKET2.9, U3.9 (A7)
/P1LED0: SOCKET2.11, U4.2 (P1LED0)
/P1LED1: R2.2, SOCKET2.10, U4.1 (P1LED1)
/PME: D1.1 (A), SOCKET2.12
/RXM1: SOCKET2.27, U4.17 (RXM1)
/RXP1: SOCKET2.26, U4.16 (RXP1)
/TXM1: SOCKET2.30, U4.20 (TXM1)
/TXP1: SOCKET2.29, U4.19 (TXP1)
/V1P8: C11.1, FB2.1, U4.8 (VDD1P8_OUT), U4.29 (VDD1P8_D)
/V1P8A: C12.1, FB2.2, U4.14 (VDD1P8_A)
/V3P3A: C10.1, FB1.2, SOCKET2.22, U4.21 (VDD3P3_A)
/XTAL1: SOCKET2.21, U4.24 (XTAL1)
/XTAL2: SOCKET2.23, U4.25 (XTAL2)
/~CMD: SOCKET2.15, U2.13
/~CS: SOCKET2.17, U2.3
/~INTR: D2.1 (A), SOCKET2.13
/~RST: SOCKET2.18, U2.1
/~WE: SOCKET2.14, U2.11
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, R1.1, R2.1, SOCKET2.16, SOCKET2.19, SOCKET2.20, SOCKET2.24, SOCKET2.25, SOCKET2.28, SOCKET2.31, U1.3 (GND), U2.7 (GND), U3.10 (GND), U4.7 (DGND), U4.13 (AGND), U4.18 (AGND), U4.26 (DGND), U4.28 (DGND), U4.30 (SD15), U4.31 (SD14), U4.32 (SD13), U4.33 (SD12), U4.34 (SD11), U4.35 (SD10), U4.36 (SD9), U4.37 (DGND), U4.39 (SD8), U5.5 (GND), U6.3 (GND)
unnamed: D1.3 (K), U4.3 (PME)
unnamed: D2.3 (K), U4.4 (~INTR)
unnamed: U2.2, U6.2
unnamed: U2.4, U2.5
unnamed: U2.9, U2.10, U3.1 (A->B), U4.5 (~RD)
unnamed: U3.18 (B0), U4.40 (SD7)
unnamed: U3.17 (B1), U4.41 (SD6)
unnamed: U3.16 (B2), U4.42 (SD5)
unnamed: U3.15 (B3), U4.43 (SD4)
unnamed: U3.14 (B4), U4.44 (SD3)
unnamed: U3.13 (B5), U4.45 (SD2)
unnamed: U3.12 (B6), U4.47 (SD1)
unnamed: U3.11 (B7), U4.48 (SD0)
unnamed: U2.6, U3.19 (CE), U4.12 (~CS)
unnamed: U2.12, U4.11 (CMD)
unnamed: U4.15 (EECS), U5.1 (CS)
unnamed: R3.1, R6.2, U4.9 (EED_IO), U5.4 (DO)
unnamed: U4.10 (EESK), U5.2 (SCLK)
unnamed: R1.2, U4.22 (ISET)
unnamed: U4.23 (~RST), U6.4
unnamed: U2.8, U4.6 (~WR)
unnamed: R6.1, U5.3 (DI)

Notes on the sheet:
TODO: - Improve signal integrity - Widen power traces - Check all footprints, component values

Board: 2 copper layers, 39.1 x 15.2 mm, 26 parts (15 on the bottom side), 50 nets.

## KiCad design boards/a1_codec/a1_codec.kicad_pcb

Schematic: a1_codec.kicad_sch, A1 Codec Board

Parts:
C1, C2, C3, C6, C7, C8, C9, C10, C11, C12, C13: 4.7u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
FB1: FerriteBead_Small; L_0402_1005Metric_Pad0.77x0.64mm_HandSolder
JP1: Jumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged2Bar_Pad1.0x1.5mm
R1, R2: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
SOCKET2: Conn_02x20_Counter_Clockwise; DIP-32_pin_header
U1: LM3480-3.3; SOT-23
U2: NAU8822; QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm
U4: 74LV6T17; TSSOP-14_4.4x5mm_P0.65mm
U6: TXS0102DCT; SSOP-8_2.95x2.8mm_P0.65mm

Connections:
+3.3V: C3.1, C6.1, C9.1, C10.1, C13.1, FB1.1, R1.1, R2.1, SOCKET2.5, U1.1 (VO), U2.13 (VDDC), U2.14 (VDDB), U4.14 (VCC), U6.3 (VCCA), U6.6 (OE)
+3.3VA: C2.1, FB1.2, U2.31 (VDDA)
+5V: C11.1, C12.1, SOCKET2.32, U1.2 (VI), U6.7 (VCCB)
/ADCOUT: SOCKET2.29, U4.6
/AUXOUT1: SOCKET2.8, U2.21 (AUXOUT1)
/AUXOUT2: SOCKET2.9, U2.22 (AUXOUT2)
/BCLK: SOCKET2.28, U4.3
/CSB: SOCKET2.1, U4.12
/CSB/GPIO1: U2.15 (CSB/GPIO1), U4.13
/DACIN: SOCKET2.30, U4.9
/FS: SOCKET2.27, U4.1
/LAUXIN: SOCKET2.7, U2.19 (LAUXIN)
/LHP: SOCKET2.15, U2.30 (LHP)
/LLIN/GPIO2: SOCKET2.24, U2.3 (LLIN/GPIO2)
/LMIC_N: SOCKET2.20, U2.2 (LMIC_N)
/LMIC_P: SOCKET2.19, U2.1 (LMIC_P)
/LSPKOUT: SOCKET2.12, U2.25 (LSPKOUT)
/MCLK: SOCKET2.31, U4.11
/MICBIAS: C8.1, SOCKET2.18, U2.32 (MICBIAS)
/RAUXIN: SOCKET2.6, U2.20 (RAUXIN)
/RHP: SOCKET2.14, U2.29 (RHP)
/RLIN/GPIO3: SOCKET2.25, U2.6 (RLIN/GPIO3)
/RMIC_N: SOCKET2.22, U2.5 (RMIC_N)
/RMIC_P: SOCKET2.21, U2.4 (RMIC_P)
/RSPKOUT: SOCKET2.11, U2.23 (RSPKOUT)
/SCLK: SOCKET2.2, U6.8 (B1)
/SDIO: SOCKET2.3, U6.1 (B2)
/V_SPKR: C7.1, SOCKET2.13, U2.26 (VDDSPK)
GND: C3.2, C6.2, C9.2, C10.2, C11.2, C12.2, C13.2, JP1.1 (A), SOCKET2.4, U1.3 (GND), U2.12 (VSSD), U2.18 (MODE), U2.33 (VSS), U4.7 (GND), U6.2 (GND)
GNDA: C1.2, C2.2, C7.2, C8.2, JP1.2 (B), SOCKET2.10, SOCKET2.16, SOCKET2.17, SOCKET2.23, SOCKET2.26, U2.24 (VSSSPK), U2.28 (VSSA)
unnamed: U2.9 (ADCOUT), U4.5
unnamed: U2.8 (BCLK), U4.4
unnamed: U2.10 (DACIN), U4.8
unnamed: U2.7 (FS), U4.2
unnamed: U2.11 (MCLK), U4.10
unnamed: R2.2, U2.16 (SCLK), U6.5 (A1)
unnamed: R1.2, U2.17 (SDIO), U6.4 (A2)
unnamed: C1.1, U2.27 (VREF)

Board: 2 copper layers, 39.1 x 15.2 mm, 20 parts (1 on the bottom side), 38 nets.

## Commit log (part)

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2023-06-04 Removing stuff after splitting repo
2023-06-04 More documentation cleanup.
2023-06-05 Realized that pin-muxing for DRAM is still incorrect.
2023-06-07 Doc update
2023-06-07 Added JFET-based protection sim. It seems to be working?
2023-06-09 Started block diagrams.
2023-06-12 Much progress on uarch docs.
2023-06-16 MemAV is properly generated, interrupt ecause is set in SCHEDULER mode.
2023-06-20 Major progress on documentation.
2023-06-20 Documentation name update
2023-06-21 VSCode config file
2023-06-26 Swapped wait-state and region-select address bits.
2023-06-28 Large documentation update
2023-06-30 Added BCT to launch options.
2023-06-30 Fixed bus-timing diagrams.
    Added proper hold timing.
    Added high-Z states for DMAs
    Added bus-req/grant diagram.
2023-06-30 Updated BCT to latest memory map.
2023-07-03 Documentation update
2023-07-07 Some documentation updates
2023-08-28 Followed-up on the most important ISA changes
    - A & ~B removed
    - PFLUSH added (not tested)
    - CSR read/write instructions added
    What's still missing:
    - exceptions are not reported as they should
    - CSR layout is wrong
2023-08-30 Fixed ecause/eaddr reporting
    Also added some minimal automated testing.
2023-09-03 New CSR layout
    Espresso now adheres to the CSR layout of Brew.
    This involves using the new reg_file infrastructure at least for
    the base CSRs.
    There was also a bug in qualifying pready in memory that depended
    on pready having a non-X default value.
2023-09-07 Fixed CSRs and reworked event counters.
2023-09-09 Registers need to be initialized on boot.
2023-09-09 Fixed address bus size for DMA controller.
2023-09-09 More benchmark results.
2023-09-12 Notes on JTAG added.
2023-09-12 Fixed DRAM write timing.
    Not the best fix (as it mocks with nCAS instead of nWE) but works,
    it seems. I'm also tired of trying to find a better, cleaner solution.
    This is after all not all that relevant: it's just an emulated DRAM
    device, so anything that works well enough is good enough.
2023-09-12 Changed simulation timeout.
2023-09-12 Removed old, stale SW examples.
2023-09-12 Added DRAM constant, changed DRAM link location.
    This later change is important because we're in TASK mode now.
    That means that mem_limit registers are potentially set up to be
    at the top of DRAM, which must be beyond the peripherals.
    Now, that's normally the case, except for the wait-state aliases.
    Luckily the wait-state setting is ignored for DRAM, so it doesn't
    matter which alias we're actually using for DRAM.
2023-09-12 Upgraded to 32-bit event counters.
2023-09-12 Added debug session notes.
2023-09-13 Regression test suite started
    This is now a small regression test for the back-to-back exception
    eaddr corruption.
2023-09-13 Interrupt test program.
2023-09-14 Checking in some missed files.
2023-09-14 Hooked up is_sim input in FPGA.
2023-09-14 Cleaned up make system
2023-09-15 More cleanup
2023-09-15 First regression test ported to the new SW framework.
2023-09-18 Implemented indirect jumps.
    These instructions were missing. Now they're not.
2023-09-18 Implemented minimal syscall support.
    This is enough to make newlib (and printf) happy.
    That is to say: 'write' to stdout and 'exit' work,
    the rest just return errors.
2023-09-18 Fixed ecause handling.
2023-09-18 Made store-conditionals adhere to the spec.
    That is, they return '0' in $rD, since they always succeed.
2023-09-19 Removed WS alias from bounds checks.
    memory base and limit registers are now leaving the top 4 bits
    of the logical address alone when translating to physical address
    and checking for AVs. This allows for code to have access to a
    piece of the address space in any WS alias.
    There also was (I think) a bug in the way base and limit calculations
    were performed for fetches: $pc and $tpc are in 16-bit quantities.
2023-09-22 Fixed DRAM and lowered fast clock to 40MHz.
    DRAM is now actually edge-detects.
    Fast clock is 4x slow clock (thus every slow-clock edge
    is a rising fast-clock edge). This allows half-fast-clock
    sampling delay of DRAM control signals, which top
    level for FPGA module does. This should help
    with setup/hold times on an actual DRAM.
2023-09-22 Simulator also changed to 4:1 clock ratio.
2023-09-23 Missing UART init prevented code from running on FPGA.
2023-09-23 Exposed bus interface to outside world.
2023-09-23 Started I/O O constraints.
    Not enabled due to confusing top-level naming of I/O.
2023-09-23 Updated linker scripts.
2023-10-01 Added single-bank DRAM configuration support.
    This is needed to allow DRAM aliasing at the top of the physical
    memory space, independent of memory configuration. This, in turn
    allows SCHEDULER to store vital info at a known location.
2023-10-02 Added call instructions.
    They are not tested yet but they seem to not have regressed anything.
2023-12-08 Cleaned up some of the CPU documentation.
2024-01-12 Checking in UnIC files.
2024-01-12 Mor UnIC (datasheet) changes
2024-01-12 Documentation updates.
2024-01-16 USB HUB 'chip' created and added; only a single MIO 'chip' is left in the design.
2024-01-23 More or less complete MINI board.
    This is a check-point before trying to incorporate the USB HUB back in.
2024-01-23 Added boot mode switch, reworked LAN IRQ, places LEDs better.
2024-01-24 Worked in wait-states for I/O, changed I/O address decode, added GPI pull-downs.
2024-01-24 A1 Mini (which is not all that mini anymore) is feature-complete.
    We have 2 ISA slots and even all the power supplies generated from +5V included.
    The +12V switcher right next to the audio output is quite a bit concerning, but
    we can always say that PWR must be 12V and we directly feed that to the ISA slots.
    (Not that PWR is all that clean...) A lot will depend on how I implement grounding,
    something that I still have to do.
2024-02-02 A1-MINI is fully routed. Also fully impedance controlled.
2024-02-02 PLL calculations added.
2024-02-04 3.3V work, before abandoning the idea.
2024-02-07 Renamed main board project.
2024-02-07 Removed stale and migrated files.
2024-02-07 Some outstanding changes related to the 5x->4x clock change.
2024-02-07 Major schematic beautification.
2024-02-07 Fixed 3.3V for SDCARD; more beautification.
2024-02-16 Improved power routing for USB.
2024-02-17 More documentation renaming
2024-02-25 Lots of ISA fixes and introduction of 16-bit slots.
    These 16-bit slots only support 8-bit transfers, but they do so in a 16-bit
    compatible fashion. 16-bit DMAs, upper IRQs and higher addresses are
    not supported.
    Th PCB is not yet updated and the schematic is ugly. Still the logic should be
    there.
2024-03-01 Rotated last DIP package, fixed up a lot of violations and warnings.
2024-03-04 Some in-progress documentation changes.
2024-03-16 Added ATX-style power button.
    This also involves a management ATTiny because discrete logic just simply doesn't fit.
    Power can be turned-off by I2C transactions and by press-and-hold the power SW.
    The power switch can also generate an interrupt. Finally, the MCU monitors ~RST
    so it can ignore I2C transactions when their pull-ups are inactive due to lack of power.
2024-03-19 Added reverse-power protection to HDMI; small cleanup
    - Reverse-current protection on HDMI (via simple diode)
    - Cleaned up diff-pair annotation on schematic
    - Added proper 3D shape for AT connector
2024-04-21 Some documentation updates.
2024-04-21 Some video and audio sims. Not very comprehensive.
2024-05-03 Reversed default power-on.
    The problem with defaulting to power-on-by-default is that there is a short
    on transient while the MCU is booting and gets to override the pull-up. This
    is mitigated now by a pull-down and an override jumper. The existence of the
    jumper now necessitates an open-emitter drive from the MCU; that is, drive-high
    for ON and float for OFF.
2024-05-18 Some documentation reorg
2024-05-18 Checking in all stale files.
2024-05-18 Moved a file where it (more) belongs.
2024-05-19 Re-wrote RF to register on inputs.
    This of course is step 1 of 1000 in rationalizing Espresso,
    but it seems to be working: registering on the inputs,
    and assuming that data is stable before accepting the transfer
    results in waaaay cleaner and smaller code.
    It passes the TB provided, but not tested in integration.
2024-05-20 Added testing against reference (old) implementation
    RF is the first test subject in this effort:
    the new modules should be drop-in replacements
    for the old one, unless something major happens.
    As such, it should be possible to create automated
    unit-tests that compare the old and the new and complain.
    In this checking the test performed is still rather limited
2024-05-22 WIP - Started working on new decode
    This version has an address generator
    for the decode ROM (which should be 1KWord large) but not the content generator for it.
    Looking at the compression logic, not sure it's going to be any better than the direct-decode version, especially since this monster will have to sit in the 'logic' domain of the fetch unit.
2024-05-22 Rewrote DECODE stage.
    This is completely untested, but synthesizes.
    It's much cleaner than the previous one, but
    unfortunately somewhat larger too. It still doesn't
    use ROMs.
2024-05-22 Decode TB runs.
    Not sure what it does, but at least, you know... it runs.
2024-05-23 Wrote simple script to create raw, unoptimized verilog.
    The generated thing passes iVerilog. Need to integrate
    with quartus flow to get something meaningful. Then,
    let the optimization work begin.
2024-05-23 Logic optimized coded.
    There's even a test: the optimized and the unoptimized
    version should never differ in their outputs.
    This is tested through some Verilog TB and indeed
    they don't.
    The synthesis results show measurable but not
    dramatic differences between the optimized and
2024-05-24 Some ignore file changes.
2024-05-25 Yet another almost complete rewrite of Decode.
    This time, it's based on the mask optimization work and
    is *much* faster to elaborate and generate code.
    It doesn't yet support simulation and - thus - completely untested.
    It also doesn't yet support selector optimization, but generates
    reasonable synthesis results. Resource usage is quite comparable
    to baseline.
2024-05-25 Simulation implemented, tested and passing!
2024-05-25 Disabling mini ISA set.
    We don't support (nor need to) this anymore. Simulation and
    synthesis speed doesn't require it.
2024-05-26 Small change to defaults in TB.
2024-05-26 Reworked comments.
2024-05-28 New execute stage compiles. Fails miserably in sim.
2024-05-30 Some debugging towards a working Execute. Still quite ways to go.
2024-05-30 More work towards functional TPC/SPC management.
    Not quite there yet.
2024-05-31 More branch-related fixes.
    Now we have issues with execution in the branch-shadow.
    WE are properly cancelling the instruction right
    after a branch, but we also are cancelling the one
    after that. This is not what the TB assumes.
    However, it might be what we want as the behavior: when do_branch goes high, every stage
    should drop what they are doing, including exec1.
2024-05-31 Exec passes unit-test!
    This is only though because PC address mismatches are not fatal.
    Those tests are tricky in this new timing world, I'll have to think about
    how to enable them again. Things *seem* to work alright, but, if it's not tested...
2024-05-31 Fixed execution of LDST in branch shadow.
    That is, the non-execution of them.
2024-06-02 Finally EXECUTE TB runs to completion even with PC checking.
    There were numerous issues both in TB and in real code, so
    I'm glad I went through this process.
    1. There was an issue in the way I handled TPC writes: these
    could cause a subsequent instruction to fetch the wrong
    value from TPC in scheduler mode, if the pipeline was full
    as we don't track dependencies through $tpc.
2024-06-03 Some logic cleanup, no significant change.
2024-06-03 Re-fixed TB for EXEC.
    Now TB correctly delays PC checking until
    it actually appears on TPC/SPC_OUT.
2024-06-03 Some signal updates.
2024-06-04 Split BusIF into TB and implementation.
    This doesn't compile stand-alone at the moment though:
    the number of DMA channels is a generic member of an interface,
    so it can't be a top level thingy.
2024-06-07 Attempt at making top level working for bus_if. Not quite there yet.
2024-06-10 Quite a bit of progress towards self-checking bus_if_tb.
    This one self-checks FETCH/MEM/DMA operations.
    No check yet for refresh cycles, also no check that
    reads return the proper expected values.
    There is also an ugly hack where the TB waits an epsilon
    to ensure that addr is stable on the falling edge of CAS.
    I'm aware of this race, in real HW, the CAS signals are
2024-06-10 Address decode is more complex than documented.
2024-06-13 Cleaned up environment.
2024-06-21 Some thinking about new bus_if. Not even remotely done.
2024-06-21 Added some checks that request types are laid out as expected.
2024-06-25 Some work towards at least some functionality.
    This would only support non-delayed DRAM accesses, but even
    that is incomplete at this point.
2024-06-26 BusIf simulation runs to completion.
    It's probably horribly broken, but, you know, progress...
2024-07-01 Some progress in BusIf.
    Now, it appears that address is properly generated and
    read data is properly captured. That is, at least for zero-WS
    transfers.
2024-07-01 Things are getting ugly and hacky again.
    So, it turns out, I totally don't understand how to break
    bursts. I think I'm trying to be a bit too aggressive on latency,
    but maybe that's not the main issue.
    It also happens that I'm eating bursts (see 4th transaction which has a second burst). I'm also not holding CAS after last beat in this case, but since it should't be the last beat to begin
    with, maybe that's a problem for later.
