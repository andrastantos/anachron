# Repository andrastantos/anachron (continued)

## KiCad design boards/a1_micro_atx/a1_micro_atx.kicad_pcb (continued)

Parts:
C54, C55, C56, C57, C68, C69, C70, C71: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
J18, J19: Bus_ISA_8bit; BUS_XT_CONN
J20, J21: Bus_ISA_16bit; BUS_AT_CONN
JP4: Jumper_3_Bridged12; PinHeader_1x03_P2.54mm_Vertical
RN10: 10k; R_Array_SIP5
U30, U37: 74AHCT245; DIP-20_W7.62mm_LongPads
U31: 74AHCT14; DIP-14_W7.62mm_LongPads
U32: 74AHCT139; DIP-16_W7.62mm_LongPads
U33: 4075; DIP-14_W7.62mm_LongPads
U38: 74HCT153; DIP-16_W7.62mm_LongPads
U41: 74LS00; DIP-14_W7.62mm_LongPads
X4: 14.31818MHz; Oscillator_DIP-14

Connections:
+5V: C54.1, C55.1, C56.1, C57.1, C68.1, C69.1, C70.1, C71.1, J18.3 (VCC), J18.29 (VCC), J19.3 (VCC), J19.29 (VCC), J20.3 (+5V), J20.29 (VCC), J20.78 (+5V), J21.3 (+5V), J21.29 (VCC), J21.78 (+5V), RN10.1 (common), U30.20 (VCC), U31.14 (VCC), U32.16 (VCC), U33.14 (VDD), U37.20 (VCC), U38.3 (I3a), U38.4 (I2a), U38.16 (VCC), U41.4, U41.14 (VCC), X4.1 (EN), X4.14 (Vcc); also elsewhere on the board
/BUF_A0: J18.62 (BA00), J19.62 (BA00), J20.62 (BA00), J21.62 (BA00), U31.5, U41.1; also elsewhere on the board
/BUF_A1: J18.61 (BA01), J19.61 (BA01), J20.61 (BA01), J21.61 (BA01); also elsewhere on the board
/BUF_A2: J18.60 (BA02), J19.60 (BA02), J20.60 (BA02), J21.60 (BA02); also elsewhere on the board
/BUF_A3: J18.59 (BA03), J19.59 (BA03), J20.59 (BA03), J21.59 (BA03); also elsewhere on the board
/BUF_A4: J18.58 (BA04), J19.58 (BA04), J20.58 (BA04), J21.58 (BA04); also elsewhere on the board
/BUF_A5: J18.57 (BA05), J19.57 (BA05), J20.57 (BA05), J21.57 (BA05); also elsewhere on the board
/BUF_A6: J18.56 (BA06), J19.56 (BA06), J20.56 (BA06), J21.56 (BA06); also elsewhere on the board
/BUF_A7: J18.55 (BA07), J19.55 (BA07), J20.55 (BA07), J21.55 (BA07); also elsewhere on the board
/BUF_A8: J18.54 (BA08), J19.54 (BA08), J20.54 (BA08), J21.54 (BA08); also elsewhere on the board
/BUF_A9: J18.53 (BA09), J19.53 (BA09), J20.53 (BA09), J21.53 (BA09); also elsewhere on the board
/BUF_A10: J18.52 (BA10), J19.52 (BA10), J20.52 (BA10), J21.52 (BA10); also elsewhere on the board
/BUF_A11: J18.51 (BA11), J19.51 (BA11), J20.51 (BA11), J21.51 (BA11); also elsewhere on the board
/BUF_A12: J18.50 (BA12), J19.50 (BA12), J20.50 (BA12), J21.50 (BA12); also elsewhere on the board
/BUF_A13: J18.49 (BA13), J19.49 (BA13), J20.49 (BA13), J21.49 (BA13); also elsewhere on the board
/BUF_A14: J18.48 (BA14), J19.48 (BA14), J20.48 (BA14), J21.48 (BA14); also elsewhere on the board
/BUF_A15: J18.47 (BA15), J19.47 (BA15), J20.47 (BA15), J21.47 (BA15); also elsewhere on the board
/BUF_A16: J18.46 (BA16), J19.46 (BA16), J20.46 (BA16), J21.46 (BA16); also elsewhere on the board
/BUF_A17: J18.45 (BA17), J19.45 (BA17), J20.45 (BA17), J21.45 (BA17); also elsewhere on the board
/BUF_A18: J18.44 (BA18), J19.44 (BA18), J20.44 (BA18), J21.44 (BA18); also elsewhere on the board
/BUF_A19: J18.43 (BA19), J19.43 (BA19), J20.43 (BA19), J21.43 (BA19); also elsewhere on the board
/BUF_A20: U32.3 (A1), U38.14 (S0); also elsewhere on the board
/BUF_D0: U30.2 (A0), U37.2 (A0); also elsewhere on the board
/BUF_D1: U30.3 (A1), U37.3 (A1); also elsewhere on the board
/BUF_D2: U30.4 (A2), U37.4 (A2); also elsewhere on the board
/BUF_D3: U30.5 (A3), U37.5 (A3); also elsewhere on the board
/BUF_D4: U30.6 (A4), U37.6 (A4); also elsewhere on the board
/BUF_D5: U30.7 (A5), U37.7 (A5); also elsewhere on the board
/BUF_D6: U30.8 (A6), U37.8 (A6); also elsewhere on the board
/BUF_D7: U30.9 (A7), U37.9 (A7); also elsewhere on the board
/BUF_DIR: U30.1 (A->B), U32.14 (A0), U37.1 (A->B); also elsewhere on the board
/CPU_DACK: J18.42 (AEN), J19.42 (AEN), J20.42 (AEN), J21.42 (AEN), U32.1 (E); also elsewhere on the board
/CPU_DRQ1: J18.18 (DRQ1), J19.18 (DRQ1), J20.18 (DRQ1), J21.18 (DRQ1); also elsewhere on the board
/CPU_DRQ2: J18.6 (DRQ2), J19.6 (DRQ2), J20.6 (DRQ2), J21.6 (DRQ2); also elsewhere on the board
/CPU_DRQ3: J18.16 (DRQ3), J19.16 (DRQ3), J20.16 (DRQ3), J21.16 (DRQ3); also elsewhere on the board
/CPU_TC: J18.27 (TC), J19.27 (TC), J20.27 (TC), J21.27 (TC); also elsewhere on the board
/CPU_~DACK1: J18.17 (~DACK1), J19.17 (~DACK1), J20.17 (~DACK1), J21.17 (~DACK1); also elsewhere on the board
/CPU_~DACK2: J18.26 (~DACK2), J19.26 (~DACK2), J20.26 (~DACK2), J21.26 (~DACK2); also elsewhere on the board
/CPU_~DACK3: J18.15 (~DACK3), J19.15 (~DACK3), J20.15 (~DACK3), J21.15 (~DACK3); also elsewhere on the board
/CPU_~DACK: U41.9; also elsewhere on the board
/CPU_~WAIT: J18.41 (IO_READY), J19.41 (IO_READY), J20.41 (IO_READY), J21.41 (IO_READY), RN10.5 (R4); also elsewhere on the board
/ISA/ISA_ALE: J18.28 (ALE), J19.28 (ALE), J20.28 (ALE), J21.28 (ALE), U31.12, U41.13
/ISA/ISA_CSH: U41.3, U41.5
/ISA/ISA_D0: J18.40 (DB0), J19.40 (DB0), J20.40 (DB0), J21.40 (DB0), U30.18 (B0)
/ISA/ISA_D1: J18.39 (DB1), J19.39 (DB1), J20.39 (DB1), J21.39 (DB1), U30.17 (B1)
/ISA/ISA_D2: J18.38 (DB2), J19.38 (DB2), J20.38 (DB2), J21.38 (DB2), U30.16 (B2)
/ISA/ISA_D3: J18.37 (DB3), J19.37 (DB3), J20.37 (DB3), J21.37 (DB3), U30.15 (B3)
/ISA/ISA_D4: J18.36 (DB4), J19.36 (DB4), J20.36 (DB4), J21.36 (DB4), U30.14 (B4)
/ISA/ISA_D5: J18.35 (DB5), J19.35 (DB5), J20.35 (DB5), J21.35 (DB5), U30.13 (B5)
/ISA/ISA_D6: J18.34 (DB6), J19.34 (DB6), J20.34 (DB6), J21.34 (DB6), U30.12 (B6)
/ISA/ISA_D7: J18.33 (DB7), J19.33 (DB7), J20.33 (DB7), J21.33 (DB7), U30.11 (B7)
/ISA/ISA_D8: J20.91 (D8), J21.91 (D8), U37.18 (B0)
/ISA/ISA_D9: J20.92 (D9), J21.92 (D9), U37.17 (B1)
/ISA/ISA_D10: J20.93 (D10), J21.93 (D10), U37.16 (B2)
/ISA/ISA_D11: J20.94 (D11), J21.94 (D11), U37.15 (B3)
/ISA/ISA_D12: J20.95 (D12), J21.95 (D12), U37.14 (B4)
/ISA/ISA_D13: J20.96 (D13), J21.96 (D13), U37.13 (B5)
/ISA/ISA_D14: J20.97 (D14), J21.97 (D14), U37.12 (B6)
/ISA/ISA_D15: J20.98 (D15), J21.98 (D15), U37.11 (B7)
/ISA/ISA_DRQ0: J20.71 (DRQ0), J21.71 (DRQ0)
/ISA/ISA_DRQ5: J20.73 (DRQ5), J21.73 (DRQ5)
/ISA/ISA_DRQ6: J20.75 (DRQ6), J21.75 (DRQ6)
/ISA/ISA_DRQ7: J20.77 (DRQ7), J21.77 (DRQ7)
/ISA/ISA_IRQ10: J20.65 (IRQ10), J21.65 (IRQ10)
/ISA/ISA_IRQ11: J20.66 (IRQ11), J21.66 (IRQ11)
/ISA/ISA_IRQ12: J20.67 (IRQ12), J21.67 (IRQ12)
/ISA/ISA_IRQ14: J20.69 (IRQ14), J21.69 (IRQ14)
/ISA/ISA_IRQ15: J20.68 (IRQ15), J21.68 (IRQ15)
/ISA/ISA_MASTER: J20.79 (MASTER), J21.79 (MASTER)
/ISA/ISA_OSC: J18.30 (OSC), J19.30 (OSC), J20.30 (OSC), J21.30 (OSC), JP4.2 (C)
/ISA/ISA_RST: J18.2 (RESET), J19.2 (RESET), J20.2 (RESET), J21.2 (RESET), U31.8
/ISA/ISA_TGR16: U38.9 (Zb), U41.2
/ISA/ISA_~CSH: U37.19 (CE), U41.6, U41.12
/ISA/ISA_~CSL: U30.19 (CE), U41.11
/ISA/ISA_~IOCS16: J20.64 (~IOCS16), J21.64 (~IOCS16), U38.5 (I1a)
/ISA/ISA_~MEMCS16: J20.63 (~MEMCS16), J21.63 (~MEMCS16), U38.6 (I0a)
/ISA/ISA_~SBHE: J20.81 (SBHE), J21.81 (SBHE), U31.6
/ISA/ISA_~TGR16: U38.7 (Za), U38.15 (Eb)
/ISA/~INT: U31.2; also elsewhere on the board
/ISA/~ISA_0WS: J18.8 (UNUSED), J19.8 (UNUSED), J20.8 (UNUSED), J21.8 (UNUSED), RN10.4 (R3)
/ISA/~ISA_DACK0: J18.19 (~DACK0), J19.19 (~DACK0), J20.19 (~REFRESH), J21.19 (~REFRESH), RN10.3 (R2)
/ISA/~ISA_IOR: J18.14 (~IOR), J19.14 (~IOR), J20.14 (~IOR), J21.14 (~IOR), U32.9 (O3)
/ISA/~ISA_IOW: J18.13 (~IOW), J19.13 (~IOW), J20.13 (~IOW), J21.13 (~IOW), U32.10 (O2)
/ISA/~ISA_IO_CH_CK: J18.32 (IO), J19.32 (IO), J20.32 (IO), J21.32 (IO), RN10.2 (R1), U31.3
/ISA/~ISA_MEMR: J18.12 (~SMEMR), J19.12 (~SMEMR), J20.12 (~SMEMR), J20.89 (~MEMR), J21.12 (~SMEMR), J21.89 (~MEMR), U32.11 (O1)
/ISA/~ISA_MEMW: J18.11 (~SMEMW), J19.11 (~SMEMW), J20.11 (~SMEMW), J20.90 (~MEMW), J21.11 (~SMEMW), J21.90 (~MEMW), U32.12 (O0)
/ISA_CH_CK: U31.4, U33.12; also elsewhere on the board
/ISA_IRQ2: J18.4 (IRQ2), J19.4 (IRQ2), J20.4 (IRQ2), J21.4 (IRQ2), U33.4; also elsewhere on the board
/ISA_IRQ3: J18.25 (IRQ3), J19.25 (IRQ3), J20.25 (IRQ3), J21.25 (IRQ3), U33.5; also elsewhere on the board
/ISA_IRQ4: J18.24 (IRQ4), J19.24 (IRQ4), J20.24 (IRQ4), J21.24 (IRQ4), U33.3; also elsewhere on the board
/ISA_IRQ5: J18.23 (IRQ5), J19.23 (IRQ5), J20.23 (IRQ5), J21.23 (IRQ5), U33.2; also elsewhere on the board
/ISA_IRQ6: J18.22 (IRQ6), J19.22 (IRQ6), J20.22 (IRQ6), J21.22 (IRQ6), U33.1; also elsewhere on the board
/ISA_IRQ7: J18.21 (IRQ7), J19.21 (IRQ7), J20.21 (IRQ7), J21.21 (IRQ7), U33.8; also elsewhere on the board
/~ISA_SEL: U31.13, U38.2 (S1), U41.10; also elsewhere on the board
GND: C54.2, C55.2, C56.2, C57.2, C68.2, C69.2, C70.2, C71.2, J18.1 (GND), J18.10 (GND), J18.31 (GND), J19.1 (GND), J19.10 (GND), J19.31 (GND), J20.1 (GND), J20.10 (GND), J20.31 (GND), J20.70 (~DACK0), J20.72 (~DACK5), J20.74 (~DACK6), J20.76 (~DACK7), J20.80 (GND), J20.82 (LA23), J20.83 (LA22), J20.84 (LA21), J20.85 (LA20), J20.86 (LA19), J20.87 (LA18), J20.88 (LA17), J21.1 (GND), J21.10 (GND), J21.31 (GND), J21.70 (~DACK0), J21.72 (~DACK5), J21.74 (~DACK6), J21.76 (~DACK7), J21.80 (GND), J21.82 (LA23), J21.83 (LA22), J21.84 (LA21), J21.85 (LA20), J21.86 (LA19), J21.87 (LA18), J21.88 (LA17), U30.10 (GND), U31.7 (GND), U32.2 (A0), U32.8 (GND), U33.7 (VSS), U37.10 (GND), U38.1 (Ea), U38.8 (GND), U38.10 (I0b), U38.11 (I1b), U38.12 (I2b), U38.13 (I3b), U41.7 (GND), X4.7 (GND); also elsewhere on the board
ISA_+12V: J18.9 (+12V), J19.9 (+12V), J20.9 (+12V), J21.9 (+12V); also elsewhere on the board
ISA_-5V: J18.5 (-5V), J19.5 (-5V), J20.5 (-5V), J21.5 (-5V); also elsewhere on the board
ISA_-12V: J18.7 (-12V), J19.7 (-12V), J20.7 (-12V), J21.7 (-12V); also elsewhere on the board
unnamed: JP4.3 (B), X4.8 (OUT)
unnamed: U31.1, U33.10
unnamed: U31.11, U41.8
unnamed: U32.4 (O0), U32.13 (A1)
unnamed: U31.10, U32.15 (E)
unnamed: U33.9, U33.11
unnamed: U33.6, U33.13
SYS_CLK: J18.20 (CLK), J19.20 (CLK), J20.20 (CLK), J21.20 (CLK), JP4.1 (A); also elsewhere on the board
~RST: U31.9; also elsewhere on the board

Notes on the sheet:
For DMA transfers, we'll have to enable ~{ISA_IOW} or ~{ISA_IOR} depending on the transfer type. ~{WE} is already in the 'right' direction, that is, it's the inverted version of that of the CPU in case of DMAs.
Optional oscillator in case there's a bunch of problems with feeding just SYS_CLK to ISA_OSC.
Truth table: ~ISA_SEL ~TRG16 ~SBHE A0 Low ~CS High ~CS Transfer type 0 0 1 0 0 1 D0-7 0 0 0 0 N/A N/A D0-15 (16-bit transfer) 0 0 1 1 N/A N/A Invalid 0 0 0 1 1 0 D7-15 0 1 1 0 0 1 D0-7 0 1 0 1 0 1 D0-7 1 X (1) X X 1 1 not addressed
Review: High and Low CS generation for both I/O, mem and DMA cycles

Parts:
C21, C22, C23: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
U21: SIMM-30x2; SIMM-30x2_VERT

Connections:
+5V: C21.1, C22.1, C23.1, U21.A1 (VCC), U21.A24 (A11), U21.A28 (~CASP), U21.A30 (VCC), U21.B1 (VCC), U21.B24 (A11), U21.B28 (~CASP), U21.B30 (VCC); also elsewhere on the board
/GFX_A0: U21.A4 (A0), U21.B4 (A0); also elsewhere on the board
/GFX_A1: U21.A5 (A1), U21.B5 (A1); also elsewhere on the board
/GFX_A2: U21.A7 (A2), U21.B7 (A2); also elsewhere on the board
/GFX_A3: U21.A8 (A3), U21.B8 (A3); also elsewhere on the board
/GFX_A4: U21.A11 (A4), U21.B11 (A4); also elsewhere on the board
/GFX_A5: U21.A12 (A5), U21.B12 (A5); also elsewhere on the board
/GFX_A6: U21.A14 (A6), U21.B14 (A6); also elsewhere on the board
/GFX_A7: U21.A15 (A7), U21.B15 (A7); also elsewhere on the board
/GFX_A8: U21.A17 (A8), U21.B17 (A8); also elsewhere on the board
/GFX_A9: U21.A18 (A9), U21.B18 (A9); also elsewhere on the board
/GFX_A10: U21.A19 (A10), U21.B19 (A10); also elsewhere on the board
/GFX_D0: U21.A3 (DQ0), U21.B3 (DQ0); also elsewhere on the board
/GFX_D1: U21.A6 (DQ1), U21.B6 (DQ1); also elsewhere on the board
/GFX_D2: U21.A10 (DQ2), U21.B10 (DQ2); also elsewhere on the board
/GFX_D3: U21.A13 (DQ3), U21.B13 (DQ3); also elsewhere on the board
/GFX_D4: U21.A16 (DQ4), U21.B16 (DQ4); also elsewhere on the board
/GFX_D5: U21.A20 (DQ5), U21.B20 (DQ5); also elsewhere on the board
/GFX_D6: U21.A23 (DQ6), U21.B23 (DQ6); also elsewhere on the board
/GFX_D7: U21.A25 (DQ7), U21.B25 (DQ7); also elsewhere on the board
/GFX_~CAS_0: U21.B2 (~CAS); also elsewhere on the board
/GFX_~CAS_1: U21.A2 (~CAS); also elsewhere on the board
/GFX_~RAS: U21.A27 (~RAS), U21.B27 (~RAS); also elsewhere on the board
/GFX_~WE: U21.A21 (~WE), U21.B21 (~WE); also elsewhere on the board
GND: C21.2, C22.2, C23.2, U21.A9 (GND), U21.A22 (GND), U21.A29 (DP), U21.B9 (GND), U21.B22 (GND), U21.B29 (DP); also elsewhere on the board

Parts of its further copies:
C51, C52, C53: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
U20: SIMM-30x2; SIMM-30x2_VERT

Connections of its further copies:
+5V: C51.1, C52.1, C53.1, U20.A1 (VCC), U20.A24 (A11), U20.A28 (~CASP), U20.A30 (VCC), U20.B1 (VCC), U20.B24 (A11), U20.B28 (~CASP), U20.B30 (VCC); also elsewhere on the board
/CPU_A0: U20.A4 (A0), U20.B4 (A0); also elsewhere on the board
/CPU_A1: U20.A5 (A1), U20.B5 (A1); also elsewhere on the board
/CPU_A2: U20.A7 (A2), U20.B7 (A2); also elsewhere on the board
/CPU_A3: U20.A8 (A3), U20.B8 (A3); also elsewhere on the board
/CPU_A4: U20.A11 (A4), U20.B11 (A4); also elsewhere on the board
/CPU_A5: U20.A12 (A5), U20.B12 (A5); also elsewhere on the board
/CPU_A6: U20.A14 (A6), U20.B14 (A6); also elsewhere on the board
/CPU_A7: U20.A15 (A7), U20.B15 (A7); also elsewhere on the board
/CPU_A8: U20.A17 (A8), U20.B17 (A8); also elsewhere on the board
/CPU_A9: U20.A18 (A9), U20.B18 (A9); also elsewhere on the board
/CPU_A10: U20.A19 (A10), U20.B19 (A10); also elsewhere on the board
/CPU_D0: U20.A20 (DQ5), U20.B20 (DQ5); also elsewhere on the board
/CPU_D1: U20.A23 (DQ6), U20.B23 (DQ6); also elsewhere on the board
/CPU_D2: U20.A25 (DQ7), U20.B25 (DQ7); also elsewhere on the board
/CPU_D3: U20.A16 (DQ4), U20.B16 (DQ4); also elsewhere on the board
/CPU_D4: U20.A13 (DQ3), U20.B13 (DQ3); also elsewhere on the board
/CPU_D5: U20.A10 (DQ2), U20.B10 (DQ2); also elsewhere on the board
/CPU_D6: U20.A6 (DQ1), U20.B6 (DQ1); also elsewhere on the board
/CPU_D7: U20.A3 (DQ0), U20.B3 (DQ0); also elsewhere on the board
/CPU_~CAS_0: U20.B2 (~CAS); also elsewhere on the board
/CPU_~CAS_1: U20.A2 (~CAS); also elsewhere on the board
/CPU_~RAS_A: U20.A27 (~RAS), U20.B27 (~RAS); also elsewhere on the board
/CPU_~WE: U20.A21 (~WE), U20.B21 (~WE); also elsewhere on the board
GND: C51.2, C52.2, C53.2, U20.A9 (GND), U20.A22 (GND), U20.A29 (DP), U20.B9 (GND), U20.B22 (GND), U20.B29 (DP); also elsewhere on the board

Notes on the sheet:
Part numbers for sockets: Molex 15-46-0330 (dual) Berg 87731-102 (dual) Autotek SMV2030-6 (dual) ???? HWS9594 (dual) ???? HWS5040 (single) ???? HWS4323 (single, plastic) AdamTech SIMM-130-VTL (single) AMP 821876-2 (single) AMP 821885-2 (dual)
DRAM: There's one FPM DRAM from ISSI still in production: IS41LV16105D. This is a 1Mx16bit (3.3V) part. To mount it on a SIMM, one would need to: - Implement level-shifters - Add a 3.3V LDO - Add a single-bit flop to capture A10 on falling edge of RAS - Add a demux to select LCAS/HCAS based on capt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
SIMM socket source: https://www.peconnectors.com/sockets-pga-cpu-and-memory/hws9594/

Parts:
C44: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C45, C46, C47, C48, C49, C50, C74: 100uF; CP_Radial_D5.0mm_P2.00mm
CMC5, CMC6, CMC7, CMC8, CMC9, CMC10: L_Ferrite_Coupled_Small; SCM2012FS
FB15, FB16, FB17, FB18, FB19, FB20: FerriteBead_Small; L_Axial_L7.0mm_D3.3mm_P2.54mm_Vertical_Fastron_MICC
J7: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
J15, J16, J17: USB_A_Stacked; GCT_USB1035-XX-X-X-X-B_REVE
JP3: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
U28: A1_USBHUB; DIP-40_W15.24mm_Socket

Connections:
+5V: C44.1, U28.35 (VCC), U28.36 (VCC), U28.37 (VCC), U28.38 (VCC), U28.39 (VCC), U28.40 (VCC); also elsewhere on the board
/I2C_SCL: U28.9 (SDA); also elsewhere on the board
/I2C_SDA: U28.8 (SCL); also elsewhere on the board
/MIO/USB_CLK: U28.22 (XTAL1/CLKIN); also elsewhere on the board
/USB/USB_DN2_D+: CMC5.1, U28.26 (USBDN2_DP)
/USB/USB_DN2_D-: CMC5.4, U28.25 (USBDN2_DM)
/USB/USB_DN3_D+: CMC6.1, U28.28 (USBDN3_DP)
/USB/USB_DN3_D-: CMC6.4, U28.27 (USBDN3_DM)
/USB/USB_DN4_D+: CMC7.1, U28.30 (USBDN4_DP)
/USB/USB_DN4_D-: CMC7.4, U28.29 (USBDN4_DM)
/USB/USB_DN5_D+: CMC8.1, U28.32 (USBDN5_DP)
/USB/USB_DN5_D-: CMC8.4, U28.31 (USBDN5_DM)
/USB/USB_DN6_D+: CMC10.1, U28.24 (USBDN1_DP)
/USB/USB_DN6_D-: CMC10.4, U28.23 (USBDN1_DM)
/USB/USB_DN7_D+: CMC9.1, U28.17 (USBDN7_DP)
/USB/USB_DN7_D-: CMC9.4, U28.16 (USBDN7_DM)
/USB/USB_DN_INT_D+: J7.3, U28.14 (USBDN6_DM)
/USB/USB_DN_INT_D-: J7.5, U28.15 (USBDN6_DP)
/USB_MAIN_D+: U28.19 (USBUP_DP); also elsewhere on the board
/USB_MAIN_D-: U28.18 (USBUP_DM); also elsewhere on the board
GND: C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C74.2, J7.7, J15.4 (GND1), J15.8 (GND2), J15.9 (Shield), J16.4 (GND1), J16.8 (GND2), J16.9 (Shield), J17.4 (GND1), J17.8 (GND2), J17.9 (Shield), JP3.1 (A), U28.10 (GND), U28.11 (GND), U28.13 (CFG_SEL1), U28.20 (GND), U28.34 (GND); also elsewhere on the board
unnamed: C74.1, J7.1, U28.1 (VBUS6)
unnamed: CMC10.2, J15.3 (D1+)
unnamed: CMC10.3, J15.2 (D1-)
unnamed: CMC9.2, J15.7 (D2+)
unnamed: CMC9.3, J15.6 (D2-)
unnamed: C45.1, FB20.2, J15.1 (VBUS1)
unnamed: C48.1, FB19.2, J15.5 (VBUS2)
unnamed: CMC5.2, J16.3 (D1+)
unnamed: CMC5.3, J16.2 (D1-)
unnamed: CMC6.2, J16.7 (D2+)
unnamed: CMC6.3, J16.6 (D2-)
unnamed: C46.1, FB15.2, J16.1 (VBUS1)
unnamed: C49.1, FB16.2, J16.5 (VBUS2)
unnamed: CMC7.2, J17.3 (D1+)
unnamed: CMC7.3, J17.2 (D1-)
unnamed: CMC8.2, J17.7 (D2+)
unnamed: CMC8.3, J17.6 (D2-)
unnamed: C47.1, FB17.2, J17.1 (VBUS1)
unnamed: C50.1, FB18.2, J17.5 (VBUS2)
unnamed: JP3.2 (B), U28.33 (CFG_SEL2)
unnamed: FB20.1, U28.4 (VBUS1)
unnamed: FB15.1, U28.5 (VBUS2)
unnamed: FB16.1, U28.6 (VBUS3)
unnamed: FB17.1, U28.7 (VBUS4)
unnamed: FB18.1, U28.2 (VBUS5)
unnamed: FB19.1, U28.3 (VBUS7)
~RST: U28.12 (~RST); also elsewhere on the board

Parts:
C20: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
U19: ESPRESSO; DIP-40_W15.24mm_Socket

Connections:
+5V: C20.1, U19.40 (VCC); also elsewhere on the board
/CPU_A0: U19.1 (A0); also elsewhere on the board
/CPU_A1: U19.2 (A1); also elsewhere on the board
/CPU_A2: U19.3 (A2); also elsewhere on the board
/CPU_A3: U19.4 (A3); also elsewhere on the board
/CPU_A4: U19.5 (A4); also elsewhere on the board
/CPU_A5: U19.6 (A5); also elsewhere on the board
/CPU_A6: U19.7 (A6); also elsewhere on the board
/CPU_A7: U19.8 (A7); also elsewhere on the board
/CPU_A8: U19.9 (A8); also elsewhere on the board
/CPU_A9: U19.10 (A9); also elsewhere on the board
/CPU_A10: U19.11 (A10); also elsewhere on the board
/CPU_D0: U19.12 (D0); also elsewhere on the board
/CPU_D1: U19.13 (D1); also elsewhere on the board
/CPU_D2: U19.14 (D2); also elsewhere on the board
/CPU_D3: U19.15 (D3); also elsewhere on the board
/CPU_D4: U19.16 (D4); also elsewhere on the board
/CPU_D5: U19.17 (D5); also elsewhere on the board
/CPU_D6: U19.18 (D6); also elsewhere on the board
/CPU_D7: U19.19 (D7); also elsewhere on the board
/CPU_DRQ0: U19.31 (DRQ_0); also elsewhere on the board
/CPU_DRQ1: U19.33 (DRQ_1); also elsewhere on the board
/CPU_DRQ2: U19.35 (DRQ_2); also elsewhere on the board
/CPU_DRQ3: U19.37 (DRQ_3); also elsewhere on the board
/CPU_TC: U19.39 (DMA_TC); also elsewhere on the board
/CPU_~CAS_0: U19.23 (~CAS_0); also elsewhere on the board
/CPU_~CAS_1: U19.24 (~CAS_1); also elsewhere on the board
/CPU_~DACK0: U19.32 (~DACK_0); also elsewhere on the board
/CPU_~DACK1: U19.34 (~DACK_1); also elsewhere on the board
/CPU_~DACK2: U19.36 (~DACK_2); also elsewhere on the board
/CPU_~DACK3: U19.38 (~DACK_3); also elsewhere on the board
/CPU_~INT: U19.30 (~INT); also elsewhere on the board
/CPU_~NREN: U19.25 (~NREN); also elsewhere on the board
/CPU_~RAS_A: U19.21 (~RAS_A); also elsewhere on the board
/CPU_~RAS_B: U19.22 (~RAS_B); also elsewhere on the board
/CPU_~WAIT: U19.27 (~WAIT); also elsewhere on the board
/CPU_~WE: U19.26 (~WE); also elsewhere on the board
GND: C20.2, U19.20 (GND); also elsewhere on the board
SYS_CLK: U19.28 (SYS_CLK); also elsewhere on the board
~RST: U19.29 (~RST); also elsewhere on the board

Parts:
C58, C63: 220uF; CP_Radial_D6.3mm_P2.50mm
C59: 302pF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C60, C65: 100uF; CP_Radial_D6.3mm_P2.50mm
C61, C62: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C64: 260p; C_Disc_D4.7mm_W2.5mm_P5.00mm
D4, D5: 1N5817; D_DO-41_SOD81_P10.16mm_Horizontal
JP5: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
L1, L2: 220uH; L_Radial_D8.7mm_P5.00mm_Fastron_07HCP
R29: 0.244Ohm; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R30, R35: 1.5k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R31, R34: 13k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R32: 0.211Ohm; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R33: 180; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
U34, U36: MC33063AP; DIP-8_W7.62mm_LongPads
U35: L79L05_TO92; TO-92_Inline

Connections:
+5V: C58.1, JP5.2 (B), R29.1, U34.6 (Vin); also elsewhere on the board
GND: C58.2, C60.1, C61.2, C62.2, C63.2, C64.2, C65.2, L1.2, R31.2, R35.2, U35.1 (GND), U36.2 (SwE), U36.4 (GND); also elsewhere on the board
ISA_+12V: C65.1, D5.1 (K), R34.1; also elsewhere on the board
ISA_-5V: C62.1, U35.3 (VO); also elsewhere on the board
ISA_-12V: C59.2, C60.2, C61.1, D4.2 (A), R30.1, U34.4 (GND), U35.2 (VI); also elsewhere on the board
unnamed: D4.1 (K), L1.1, U34.2 (SwE)
unnamed: D5.2 (A), L2.2, U36.1 (SwC)
unnamed: C63.1, JP5.1 (A), R32.1, U36.6 (Vin)
unnamed: R29.2, U34.1 (SwC), U34.7 (Ipk), U34.8 (DC)
unnamed: C59.1, U34.3 (TC)
unnamed: R30.2, R31.1, U34.5 (Vfb)
unnamed: R33.1, U36.8 (DC)
unnamed: L2.1, R32.2, R33.2, U36.7 (Ipk)
unnamed: C64.1, U36.3 (TC)
unnamed: R34.2, R35.1, U36.5 (Vfb)

Notes on the sheet:
The original PC supplied 0.3A on the -5V and 0.25 on the -12V rails. It had 5 expansion slots. We provide about half of that current for about half of the slots. However it is anticipated that -5V is not used at all and -12 is used by RS232 transceivers only.
The original PC provided several amps on +12V. We obviously can't match that, but we don't expect much load on the +12V rail either.
30mV ripple @ 120mA
200mV ripple @ 120mA
Designed using http://www.nomad.ee/micros/mc34063a/index.shtml
Other supply options (dual channel): TPS6513x - this seems to fit the bill BD8316GWL - this can't generate -12, only about -9. R1283x - this seems to fit the bill MAX864 - switched capacitor +/-10V @ 100mA D81870EFV - seems to fit the bill ADP5071 - seems to fit the bill max743 - low current, expen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
