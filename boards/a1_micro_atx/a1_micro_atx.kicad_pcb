File: boards/a1_micro_atx/a1_micro_atx.kicad_pcb (KiCad board)
At the start: 4 copper layers, 201.9 x 204.5 mm, 219 parts, among them J1 Conn_01x01, J10 HDMI_A, J11 SJ1-3535NG-BE, J12 DE9_Plug, J13 Micro_SD_Card, J15 USB_A_Stacked, J16 USB_A_Stacked, J17 USB_A_Stacked, J18 Bus_ISA_8bit, J19 Bus_ISA_8bit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

Commit message: Major schematic beautification.
Connections:
- net /nNR_DECODE_EN renamed /~{NR_DECODE_EN}
- J1 pad 1: unconnected-(J1-Pin_1-Pad1) -> GND
- J2 pad 1: unconnected-(J2-Pin_1-Pad1) -> GND
- J3 pad 1: unconnected-(J3-Pin_1-Pad1) -> GND
- J4 pad 1: unconnected-(J4-Pin_1-Pad1) -> GND
- U31 pad 2: unconnected-(U31-Pad2) -> /ISA/~{INT}
- U31 pad 5: unconnected-(U31-Pad5) -> GND
- U32 pad 1: (no net) -> GND
- U32 pad 2: (no net) -> GND
- U32 pad 3: (no net) -> GND
- U32 pad 4: (no net) -> unconnected-(U32A-O0-Pad4)
- U32 pad 5: (no net) -> unconnected-(U32A-O1-Pad5)
- U32 pad 6: (no net) -> unconnected-(U32A-O2-Pad6)
- U32 pad 7: (no net) -> unconnected-(U32A-O3-Pad7)
- U7 pad 1: unconnected-(U7-Pad1) -> GND
- U7 pad 11: unconnected-(U7-Pad11) -> +5V
Routing:
- net /ISA/~{INT}: track 12.3 -> 102.0 mm, vias 0 -> 1
- net GND: track 2646.4 -> 2705.7 mm
- net +5V: track 1959.3 -> 1962.5 mm

Commit message: Fixed 3.3V for SDCARD; more beautification.
Parts:
- added C66: 1uF, Capacitor_THT:C_Disc_D4.7mm_W2.5mm_P5.00mm, F.Cu at (261.0, 215.9)
- added C67: 1uF, Capacitor_THT:C_Disc_D4.7mm_W2.5mm_P5.00mm, F.Cu at (252.1, 215.9)
- added U29: L78L33ABZ-AP, Package_TO_SOT_THT:TO-92_Inline, F.Cu at (255.3, 213.4)
- moved JP1 4.44 mm to (270.5, 219.1)
- moved R20 2.54 mm to (248.9, 210.8)
Connections:
- J13 pad 4: +5V -> /MIO/VCC_SD
- R20 pad 2: +5V -> /MIO/VCC_SD
- RN8 pad 1: +5V -> /MIO/VCC_SD
- RN9 pad 1: +5V -> /MIO/VCC_SD
Routing:
- net /MIO/VCC_SD: track 0.00 -> 75.2 mm, vias 0 -> 4
- net /MIO/SD_D0: track 40.9 -> 44.9 mm
- net /MIO/SD_D1: track 37.1 -> 40.8 mm
- net GND: track 2705.7 -> 2708.7 mm
- net /USB_MAIN_D-: track 202.3 -> 204.4 mm
- net /USB_MAIN_D+: track 204.7 -> 206.8 mm
- net /~{MRST}: track 194.1 -> 192.3 mm
- net +5V: track 1962.5 -> 1960.9 mm, vias 20 -> 19
- net Net-(JP1-A): track 338.0 -> 336.4 mm
- net Net-(J13-DET): track 72.1 -> 71.3 mm

Commit message: Moved USB HUB ports around.
Connections:
- CMC10 pad 1: /USB/USB_DN7_D+ -> /USB/USB_DN6_D+
- CMC10 pad 4: /USB/USB_DN7_D- -> /USB/USB_DN6_D-
- CMC9 pad 1: /USB/USB_DN6_D+ -> /USB/USB_DN7_D+
- CMC9 pad 4: /USB/USB_DN6_D- -> /USB/USB_DN7_D-
- FB19 pad 1: Net-(U28-VBUS6) -> Net-(U28-VBUS7)
- FB20 pad 1: Net-(U28-VBUS7) -> Net-(U28-VBUS1)
- U28 pad 1: Net-(U28-VBUS6) -> unconnected-(U28-VBUS6-Pad1)
- U28 pad 14: /USB/USB_DN6_D- -> unconnected-(U28-USBDN6_DM-Pad14)
- U28 pad 15: /USB/USB_DN6_D+ -> unconnected-(U28-USBDN6_DP-Pad15)
- U28 pad 23: unconnected-(U28-USBDN1_DM-Pad23) -> /USB/USB_DN6_D-
- U28 pad 24: unconnected-(U28-USBDN1_DP-Pad24) -> /USB/USB_DN6_D+
- U28 pad 4: unconnected-(U28-VBUS1-Pad4) -> Net-(U28-VBUS1)
Routing:
- net Net-(U28-VBUS1): track 0.00 -> 107.0 mm
- net Net-(U28-VBUS6): track 106.1 -> 0.00 mm
- net /USB/USB_DN6_D-: track 63.8 -> 35.9 mm
- net /USB/USB_DN6_D+: track 60.1 -> 36.0 mm
- net /USB/USB_DN7_D-: track 54.4 -> 56.4 mm
- net /USB/USB_DN7_D+: track 53.0 -> 54.8 mm
- net /VIDEO_HPD: track 307.2 -> 305.8 mm
- net /VIDEO_DDC_SCL: track 283.0 -> 281.6 mm
- net Net-(U28-VBUS7): track 107.0 -> 105.7 mm

Commit message: Improved power routing for USB.
Parts:
- moved R19 103.4 mm to (266.1, 132.1)
- moved C45 5.71 mm to (270.8, 61.0)
- moved C48 5.71 mm to (270.8, 66.7)
Routing:
- net /MIO/SER_CTS: track 245.1 -> 113.7 mm, vias 2 -> 0
- net Net-(U24-R2OUT): track 6.16 -> 128.2 mm, vias 0 -> 2
- net Net-(U28-VBUS3): track 83.6 -> 117.4 mm
- net Net-(U28-VBUS1): track 107.0 -> 138.3 mm
- net Net-(U28-VBUS7): track 105.7 -> 134.0 mm
- net Net-(U28-VBUS2): track 89.2 -> 115.1 mm
- net Net-(U28-VBUS5): track 67.6 -> 91.4 mm, vias 1 -> 2
- net Net-(U28-VBUS4): track 71.9 -> 94.1 mm
- net Net-(J15-VBUS1): track 38.7 -> 31.4 mm
- net Net-(J15-VBUS2): track 31.1 -> 34.1 mm
- net Net-(U24-R1OUT): track 261.8 -> 264.0 mm
- net /MIO/SER_TXD: track 258.5 -> 260.7 mm
- net /MIO/SER_RTS: track 250.2 -> 252.5 mm
