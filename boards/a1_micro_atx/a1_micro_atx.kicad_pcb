# Repository andrastantos/anachron (continued)

## KiCad design boards/a1_mega/a1_mega.kicad_pcb (continued)

Parts:
C15, C16, C51, C56: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
J1, J2, J3, J4: Bus_ISA_8bit; BUS_XT_CONN
JP4: Jumper_3_Bridged12; PinHeader_1x03_P2.54mm_Vertical
RN4: 10k; R_Array_SIP4
RN5, RN7: 10k; R_Array_SIP9
U1: 74LS139; DIP-16_W7.62mm_LongPads
U7: 74LS04; DIP-14_W7.62mm_LongPads
U9: 74LS86; DIP-14_W7.62mm_LongPads
U22, U23: 74LS125; DIP-14_W7.62mm_LongPads
U35: L79L05_TO92; TO-92_Inline
X4: 14.31818MHz; Oscillator_DIP-14

Connections:
+5V: C51.1, C56.1, J1.3 (VCC), J1.29 (VCC), J2.3 (VCC), J2.29 (VCC), J3.3 (VCC), J3.29 (VCC), J4.3 (VCC), J4.29 (VCC), RN7.1 (common), U22.14 (VCC), U23.14 (VCC), X4.1 (EN), X4.14 (Vcc); also elsewhere on the board
+12V: J1.9 (+12V), J2.9 (+12V), J3.9 (+12V), J4.9 (+12V); also elsewhere on the board
-12V: C16.1, J1.7 (-12V), J2.7 (-12V), J3.7 (-12V), J4.7 (-12V), U35.2 (VI); also elsewhere on the board
/BUF_TC: U9.4; also elsewhere on the board
/BUF_~WE: U1.14 (A0); also elsewhere on the board
/CPU_DACK: U9.9; also elsewhere on the board
/CPU_DRQ1: U23.3; also elsewhere on the board
/CPU_DRQ2: U23.6; also elsewhere on the board
/CPU_DRQ3: U23.8; also elsewhere on the board
/CPU_~DACK1: U23.12; also elsewhere on the board
/CPU_~DACK2: U22.2; also elsewhere on the board
/CPU_~DACK3: U22.5; also elsewhere on the board
/ISA/ISA_-5V: C15.1, J1.5 (-5V), J2.5 (-5V), J3.5 (-5V), J4.5 (-5V), U35.3 (VO)
/ISA/ISA_A0: J1.62 (BA00), J2.62 (BA00), J3.62 (BA00), J4.62 (BA00)
/ISA/ISA_A1: J1.61 (BA01), J2.61 (BA01), J3.61 (BA01), J4.61 (BA01)
/ISA/ISA_A2: J1.60 (BA02), J2.60 (BA02), J3.60 (BA02), J4.60 (BA02)
/ISA/ISA_A3: J1.59 (BA03), J2.59 (BA03), J3.59 (BA03), J4.59 (BA03)
/ISA/ISA_A4: J1.58 (BA04), J2.58 (BA04), J3.58 (BA04), J4.58 (BA04)
/ISA/ISA_A5: J1.57 (BA05), J2.57 (BA05), J3.57 (BA05), J4.57 (BA05)
/ISA/ISA_A6: J1.56 (BA06), J2.56 (BA06), J3.56 (BA06), J4.56 (BA06)
/ISA/ISA_A7: J1.55 (BA07), J2.55 (BA07), J3.55 (BA07), J4.55 (BA07)
/ISA/ISA_A8: J1.54 (BA08), J2.54 (BA08), J3.54 (BA08), J4.54 (BA08)
/ISA/ISA_A9: J1.53 (BA09), J2.53 (BA09), J3.53 (BA09), J4.53 (BA09)
/ISA/ISA_A10: J1.52 (BA10), J2.52 (BA10), J3.52 (BA10), J4.52 (BA10)
/ISA/ISA_A11: J1.51 (BA11), J2.51 (BA11), J3.51 (BA11), J4.51 (BA11)
/ISA/ISA_A12: J1.50 (BA12), J2.50 (BA12), J3.50 (BA12), J4.50 (BA12)
/ISA/ISA_A13: J1.49 (BA13), J2.49 (BA13), J3.49 (BA13), J4.49 (BA13)
/ISA/ISA_A14: J1.48 (BA14), J2.48 (BA14), J3.48 (BA14), J4.48 (BA14)
/ISA/ISA_A15: J1.47 (BA15), J2.47 (BA15), J3.47 (BA15), J4.47 (BA15)
/ISA/ISA_A16: J1.46 (BA16), J2.46 (BA16), J3.46 (BA16), J4.46 (BA16)
/ISA/ISA_A17: J1.45 (BA17), J2.45 (BA17), J3.45 (BA17), J4.45 (BA17)
/ISA/ISA_A18: J1.44 (BA18), J2.44 (BA18), J3.44 (BA18), J4.44 (BA18)
/ISA/ISA_A19: J1.43 (BA19), J2.43 (BA19), J3.43 (BA19), J4.43 (BA19)
/ISA/ISA_A20: U1.13 (A1)
/ISA/ISA_AEN: J1.42 (AEN), J2.42 (AEN), J3.42 (AEN), J4.42 (AEN), U9.8
/ISA/ISA_ALE: J1.28 (ALE), J2.28 (ALE), J3.28 (ALE), J4.28 (ALE), U7.8
/ISA/ISA_D0: J1.40 (DB0), J2.40 (DB0), J3.40 (DB0), J4.40 (DB0)
/ISA/ISA_D1: J1.39 (DB1), J2.39 (DB1), J3.39 (DB1), J4.39 (DB1)
/ISA/ISA_D2: J1.38 (DB2), J2.38 (DB2), J3.38 (DB2), J4.38 (DB2)
/ISA/ISA_D3: J1.37 (DB3), J2.37 (DB3), J3.37 (DB3), J4.37 (DB3)
/ISA/ISA_D4: J1.36 (DB4), J2.36 (DB4), J3.36 (DB4), J4.36 (DB4)
/ISA/ISA_D5: J1.35 (DB5), J2.35 (DB5), J3.35 (DB5), J4.35 (DB5)
/ISA/ISA_D6: J1.34 (DB6), J2.34 (DB6), J3.34 (DB6), J4.34 (DB6)
/ISA/ISA_D7: J1.33 (DB7), J2.33 (DB7), J3.33 (DB7), J4.33 (DB7)
/ISA/ISA_DRQ1: J1.18 (DRQ1), J2.18 (DRQ1), J3.18 (DRQ1), J4.18 (DRQ1), RN4.4 (R3), U23.2
/ISA/ISA_DRQ2: J1.6 (DRQ2), J2.6 (DRQ2), J3.6 (DRQ2), J4.6 (DRQ2), RN4.3 (R2), U23.5
/ISA/ISA_IOCHRDY: J1.41 (IO_READY), J2.41 (IO_READY), J3.41 (IO_READY), J4.41 (IO_READY), RN7.9 (R8), U22.10
/ISA/ISA_OSC: J1.30 (OSC), J2.30 (OSC), J3.30 (OSC), J4.30 (OSC), JP4.2 (C)
/ISA/ISA_RST: J1.2 (RESET), J2.2 (RESET), J3.2 (RESET), J4.2 (RESET), U7.6
/ISA/ISA_TC: J1.27 (TC), J2.27 (TC), J3.27 (TC), J4.27 (TC), U9.6
/ISA/~ISA_0WS: J1.8 (UNUSED), J2.8 (UNUSED), J3.8 (UNUSED), J4.8 (UNUSED), RN7.4 (R3)
/ISA/~ISA_DACK0: J1.19 (~DACK0), J2.19 (~DACK0), J3.19 (~DACK0), J4.19 (~DACK0), RN7.5 (R4)
/ISA/~ISA_DACK1: J1.17 (~DACK1), J2.17 (~DACK1), J3.17 (~DACK1), J4.17 (~DACK1), RN7.6 (R5), U23.11
/ISA/~ISA_DACK2: J1.26 (~DACK2), J2.26 (~DACK2), J3.26 (~DACK2), J4.26 (~DACK2), RN7.7 (R6), U22.3
/ISA/~ISA_DACK3: J1.15 (~DACK3), J2.15 (~DACK3), J3.15 (~DACK3), J4.15 (~DACK3), RN7.8 (R7), U22.6
/ISA/~ISA_IOR: J1.14 (~IOR), J2.14 (~IOR), J3.14 (~IOR), J4.14 (~IOR), U1.9 (O3)
/ISA/~ISA_IOW: J1.13 (~IOW), J2.13 (~IOW), J3.13 (~IOW), J4.13 (~IOW), U1.10 (O2)
/ISA/~ISA_MEMR: J1.12 (~SMEMR), J2.12 (~SMEMR), J3.12 (~SMEMR), J4.12 (~SMEMR), U1.11 (O1)
/ISA/~ISA_MEMW: J1.11 (~SMEMW), J2.11 (~SMEMW), J3.11 (~SMEMW), J4.11 (~SMEMW), U1.12 (O0)
/ISA_IRQ2: J1.4 (IRQ2), J2.4 (IRQ2), J3.4 (IRQ2), J4.4 (IRQ2), RN5.7 (R6); also elsewhere on the board
/ISA_IRQ3: J1.25 (IRQ3), J2.25 (IRQ3), J3.25 (IRQ3), J4.25 (IRQ3), RN5.6 (R5); also elsewhere on the board
/ISA_IRQ4: J1.24 (IRQ4), J2.24 (IRQ4), J3.24 (IRQ4), J4.24 (IRQ4), RN5.5 (R4); also elsewhere on the board
/ISA_IRQ5: J1.23 (IRQ5), J2.23 (IRQ5), J3.23 (IRQ5), J4.23 (IRQ5), RN5.4 (R3); also elsewhere on the board
/ISA_IRQ6: J1.22 (IRQ6), J2.22 (IRQ6), J3.22 (IRQ6), J4.22 (IRQ6), RN5.3 (R2); also elsewhere on the board
/ISA_IRQ7: J1.21 (IRQ7), J2.21 (IRQ7), J3.21 (IRQ7), J4.21 (IRQ7), RN5.2 (R1); also elsewhere on the board
/~ISA_DMA1_EN: U23.1, U23.13; also elsewhere on the board
/~ISA_DMA2_EN: U22.1, U23.4; also elsewhere on the board
/~ISA_IO_CH_CK: J1.32 (IO), J2.32 (IO), J3.32 (IO), J4.32 (IO), RN7.3 (R2); also elsewhere on the board
/~ISA_SEL: U1.15 (E), U7.9; also elsewhere on the board
GND: C15.2, C16.2, C51.2, C56.2, J1.1 (GND), J1.10 (GND), J1.31 (GND), J2.1 (GND), J2.10 (GND), J2.31 (GND), J3.1 (GND), J3.10 (GND), J3.31 (GND), J4.1 (GND), J4.10 (GND), J4.31 (GND), RN4.1 (common), RN5.1 (common), U9.5, U9.10, U22.7 (GND), U22.9, U23.7 (GND), U35.1 (GND), X4.7 (GND); also elsewhere on the board
unnamed: JP4.3 (B), X4.8 (OUT)
SYS_CLK: J1.20 (CLK), J2.20 (CLK), J3.20 (CLK), J4.20 (CLK), JP4.1 (A); also elsewhere on the board
~RST: U7.5; also elsewhere on the board

Notes on the sheet:
Optional oscillator in case there's a bunch of problems with feeding just SYS_CLK to this ISA pin.

Parts:
C47, C48, C49, C50: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
U20, U21: SIMM-30

Connections:
+5V: C47.1, C48.1, C49.1, C50.1, U20.1 (VCC), U20.24 (A11), U20.28 (~CASP), U20.30 (VCC), U21.1 (VCC), U21.24 (A11), U21.28 (~CASP), U21.30 (VCC); also elsewhere on the board
/CPU/A0: U20.4 (A0), U21.4 (A0); also elsewhere on the board
/CPU/A1: U20.5 (A1), U21.5 (A1); also elsewhere on the board
/CPU/A2: U20.7 (A2), U21.7 (A2); also elsewhere on the board
/CPU/A3: U20.8 (A3), U21.8 (A3); also elsewhere on the board
/CPU/A4: U20.11 (A4), U21.11 (A4); also elsewhere on the board
/CPU/A5: U20.12 (A5), U21.12 (A5); also elsewhere on the board
/CPU/A6: U20.14 (A6), U21.14 (A6); also elsewhere on the board
/CPU/A7: U20.15 (A7), U21.15 (A7); also elsewhere on the board
/CPU/A8: U20.17 (A8), U21.17 (A8); also elsewhere on the board
/CPU/A9: U20.18 (A9), U21.18 (A9); also elsewhere on the board
/CPU/A10: U20.19 (A10), U21.19 (A10)
/CPU/D0: U20.3 (DQ0), U21.3 (DQ0); also elsewhere on the board
/CPU/D1: U20.6 (DQ1), U21.6 (DQ1); also elsewhere on the board
/CPU/D2: U20.10 (DQ2), U21.10 (DQ2); also elsewhere on the board
/CPU/D3: U20.13 (DQ3), U21.13 (DQ3); also elsewhere on the board
/CPU/D4: U20.16 (DQ4), U21.16 (DQ4); also elsewhere on the board
/CPU/D5: U20.20 (DQ5), U21.20 (DQ5); also elsewhere on the board
/CPU/D6: U20.23 (DQ6), U21.23 (DQ6); also elsewhere on the board
/CPU/D7: U20.25 (DQ7), U21.25 (DQ7); also elsewhere on the board
/CPU_~CAS_0: U21.2 (~CAS); also elsewhere on the board
/CPU_~CAS_1: U20.2 (~CAS); also elsewhere on the board
/CPU_~RAS_A: U20.27 (~RAS), U21.27 (~RAS); also elsewhere on the board
/CPU_~WE: U20.21 (~WE), U21.21 (~WE); also elsewhere on the board
GND: C47.2, C48.2, C49.2, C50.2, U20.9 (GND), U20.22 (GND), U21.9 (GND), U21.22 (GND); also elsewhere on the board

Parts of its further copies:
C52, C53, C54, C55: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
U30, U31: SIMM-30

Connections of its further copies:
+5V: C52.1, C53.1, C54.1, C55.1, U30.1 (VCC), U30.24 (A11), U30.28 (~CASP), U30.30 (VCC), U31.1 (VCC), U31.24 (A11), U31.28 (~CASP), U31.30 (VCC); also elsewhere on the board
/GFX_A0: U30.4 (A0), U31.4 (A0); also elsewhere on the board
/GFX_A1: U30.5 (A1), U31.5 (A1); also elsewhere on the board
/GFX_A2: U30.7 (A2), U31.7 (A2); also elsewhere on the board
/GFX_A3: U30.8 (A3), U31.8 (A3); also elsewhere on the board
/GFX_A4: U30.11 (A4), U31.11 (A4); also elsewhere on the board
/GFX_A5: U30.12 (A5), U31.12 (A5); also elsewhere on the board
/GFX_A6: U30.14 (A6), U31.14 (A6); also elsewhere on the board
/GFX_A7: U30.15 (A7), U31.15 (A7); also elsewhere on the board
/GFX_A8: U30.17 (A8), U31.17 (A8); also elsewhere on the board
/GFX_A9: U30.18 (A9), U31.18 (A9)
/GFX_A10: U30.19 (A10), U31.19 (A10)
/GFX_D0: U30.3 (DQ0), U31.3 (DQ0); also elsewhere on the board
/GFX_D1: U30.6 (DQ1), U31.6 (DQ1); also elsewhere on the board
/GFX_D2: U30.10 (DQ2), U31.10 (DQ2); also elsewhere on the board
/GFX_D3: U30.13 (DQ3), U31.13 (DQ3); also elsewhere on the board
/GFX_D4: U30.16 (DQ4), U31.16 (DQ4); also elsewhere on the board
/GFX_D5: U30.20 (DQ5), U31.20 (DQ5); also elsewhere on the board
/GFX_D6: U30.23 (DQ6), U31.23 (DQ6); also elsewhere on the board
/GFX_D7: U30.25 (DQ7), U31.25 (DQ7); also elsewhere on the board
/GFX_~CAS_0: U31.2 (~CAS); also elsewhere on the board
/GFX_~CAS_1: U30.2 (~CAS); also elsewhere on the board
/GFX_~RAS: U30.27 (~RAS), U31.27 (~RAS); also elsewhere on the board
/GFX_~WE: U30.21 (~WE), U31.21 (~WE); also elsewhere on the board
GND: C52.2, C53.2, C54.2, C55.2, U30.9 (GND), U30.22 (GND), U31.9 (GND), U31.22 (GND); also elsewhere on the board

Parts:
C46: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
U19: ESPRESSO; DIP-40_W15.24mm_Socket

Connections:
+5V: C46.1, U19.40 (VCC); also elsewhere on the board
/CPU/A0: U19.1 (A0), U19.11 (A10); also elsewhere on the board
/CPU/A1: U19.2 (A1); also elsewhere on the board
/CPU/A2: U19.3 (A2); also elsewhere on the board
/CPU/A3: U19.4 (A3); also elsewhere on the board
/CPU/A4: U19.5 (A4); also elsewhere on the board
/CPU/A5: U19.6 (A5); also elsewhere on the board
/CPU/A6: U19.7 (A6); also elsewhere on the board
/CPU/A7: U19.8 (A7); also elsewhere on the board
/CPU/A8: U19.9 (A8); also elsewhere on the board
/CPU/A9: U19.10 (A9); also elsewhere on the board
/CPU/D0: U19.12 (D0); also elsewhere on the board
/CPU/D1: U19.13 (D1); also elsewhere on the board
/CPU/D2: U19.14 (D2); also elsewhere on the board
/CPU/D3: U19.15 (D3); also elsewhere on the board
/CPU/D4: U19.16 (D4); also elsewhere on the board
/CPU/D5: U19.17 (D5); also elsewhere on the board
/CPU/D6: U19.18 (D6); also elsewhere on the board
/CPU/D7: U19.19 (D7); also elsewhere on the board
/CPU_DRQ0: U19.31 (DRQ_0); also elsewhere on the board
/CPU_DRQ1: U19.33 (DRQ_1); also elsewhere on the board
/CPU_DRQ2: U19.35 (DRQ_2); also elsewhere on the board
/CPU_DRQ3: U19.37 (DRQ_3); also elsewhere on the board
/CPU_TC: U19.39 (DMA_TC); also elsewhere on the board
/CPU_~CAS_0: U19.23 (~CAS_0); also elsewhere on the board
/CPU_~CAS_1: U19.24 (~CAS_1); also elsewhere on the board
/CPU_~DACK0: U19.32 (~DACK_0); also elsewhere on the board
/CPU_~DACK1: U19.34 (~DACK_1); also elsewhere on the board
/CPU_~DACK2: U19.36 (~DACK_2); also elsewhere on the board
/CPU_~DACK3: U19.38 (~DACK_3); also elsewhere on the board
/CPU_~INT: U19.30 (~INT); also elsewhere on the board
/CPU_~NREN: U19.25 (~NREN); also elsewhere on the board
/CPU_~RAS_A: U19.21 (~RAS_A); also elsewhere on the board
/CPU_~RAS_B: U19.22 (~RAS_B); also elsewhere on the board
/CPU_~WE: U19.26 (~WE); also elsewhere on the board
GND: C46.2, U19.20 (GND); also elsewhere on the board
SYS_CLK: U19.28 (SYS_CLK); also elsewhere on the board
~RST: U19.29 (~RST); also elsewhere on the board

Parts:
C1, C13: 1uF; CP_Radial_D4.0mm_P2.00mm
C2, C3: 220uF; CP_Radial_D7.5mm_P2.50mm
C14: 4.7uF; CP_Radial_D4.0mm_P2.00mm
C57, C58, C59: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
CMC1, CMC2, CMC3, CMC4: L_Ferrite_Coupled_Small; SCM2012FS
F1: 0.5A; Fuse_BelFuse_0ZRE0005FF_L8.3mm_W3.8mm
FB1: FerriteBead_Small; L_Axial_L5.3mm_D2.2mm_P7.62mm_Horizontal_Vishay_IM-1
FB13, FB14, FB15, FB16, FB17, FB18, FB19, FB20: FerriteBead_Small; L_Axial_L7.0mm_D3.3mm_P2.54mm_Vertical_Fastron_MICC
J5: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J6: HDMI_A; HDMI_A_Molex_208658-1001_Horizontal
J12, J13: SJ1-3535NG-BE; CUI_SJ1-3535NG-BE; PARTREV 1.0
JP1: Jumper_3_Open; PinHeader_1x03_P2.54mm_Vertical
R1, R19: 220k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2, R3: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R7, R18, R20, R21: 47k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
TP2: TestPoint_Alt; TestPoint_Plated_Hole_D2.0mm
U24: DISCO; DIP-40_W15.24mm_Socket
U25: A1_CODEC; DIP-32_W15.24mm_LongPads
X1: CXO_DIP14; Oscillator_DIP-14

Connections:
+5V: C57.1, C58.1, C59.1, F1.2, JP1.1 (A), U24.40 (VCC), U25.32 (VCC_5), X1.1 (EN), X1.14 (Vcc); also elsewhere on the board
/CPU_~INT: U24.30 (~INT); also elsewhere on the board
/GFX/AUDIO_SDATA_IN: U24.22 (AUDIO_SDATA_IN), U25.29 (ADCOUT)
/GFX/AUDIO_SDATA_OUT: U24.21 (AUDIO_SDATA_OUT), U25.30 (DACIN)
/GFX/AUDIO_SFRM: U24.19 (AUDIO_SFRM), U25.27 (FS)
/GFX/CODEC_V3P3: JP1.3 (B), R1.1, R19.1, U25.5 (3P3_OUT)
/GFX/HP_DET: J12.4, R1.2, U25.24 (LLIN/GPIO2)
/GFX/LINE_IN_DET: J13.4, R19.2, U25.25 (RLIN/GPIO3)
/GFX_A0: U24.9 (A0); also elsewhere on the board
/GFX_A1: U24.10 (A1); also elsewhere on the board
/GFX_A2: U24.11 (A2); also elsewhere on the board
/GFX_A3: U24.12 (A3); also elsewhere on the board
/GFX_A4: U24.13 (A4); also elsewhere on the board
/GFX_A5: U24.14 (A5); also elsewhere on the board
/GFX_A6: U24.15 (A6); also elsewhere on the board
/GFX_A7: U24.16 (A7); also elsewhere on the board
/GFX_A8: U24.17 (A8); also elsewhere on the board
/GFX_D0: U24.32 (D0); also elsewhere on the board
/GFX_D1: U24.33 (D1); also elsewhere on the board
/GFX_D2: U24.34 (D2); also elsewhere on the board
/GFX_D3: U24.35 (D3); also elsewhere on the board
/GFX_D4: U24.36 (D4); also elsewhere on the board
/GFX_D5: U24.37 (D5); also elsewhere on the board
/GFX_D6: U24.38 (D6); also elsewhere on the board
/GFX_D7: U24.39 (D7); also elsewhere on the board
/GFX_~CAS_0: U24.24 (~CAS_0); also elsewhere on the board
/GFX_~CAS_1: U24.25 (~CAS_1); also elsewhere on the board
/GFX_~RAS: U24.23 (~RAS_A); also elsewhere on the board
/GFX_~WE: U24.27 (~WE); also elsewhere on the board
/I2C_SCL: U25.3 (SDIO); also elsewhere on the board
/I2C_SDA: U25.2 (SCLK); also elsewhere on the board
/VIDEO_DDC_SCL: FB13.1; also elsewhere on the board
/VIDEO_DDC_SDA: FB14.1; also elsewhere on the board
/VIDEO_HPD: FB20.1; also elsewhere on the board
/~GFX_SEL: U24.26 (~REG_SEL); also elsewhere on the board
GND: C14.2, C57.2, C58.2, C59.2, J6.2 (D2S), J6.5 (D1S), J6.8 (D0S), J6.11 (CKS), J6.17 (GND), J6.SH, J12.1, J13.1, R2.1, R3.1, R7.2, R18.2, R20.2, R21.2, U24.20 (GND), U25.4 (GND), U25.10 (AGND), U25.16 (AGND), U25.17 (AGND), U25.23 (AGND), U25.26 (AGND), X1.7 (GND); also elsewhere on the board
unnamed: C1.2, FB18.2, R20.1
unnamed: C2.2, FB16.2, R18.1
unnamed: C3.2, FB17.2, R7.1
unnamed: C13.2, FB19.2, R21.1
unnamed: F1.1, FB15.2
unnamed: FB16.1, J12.2
unnamed: FB17.1, J12.3
unnamed: FB18.1, J13.2
unnamed: FB19.1, J13.3
unnamed: J5.1, U25.12 (LSPKOUT)
unnamed: J5.2, U25.11 (RSPKOUT)
unnamed: FB15.1, J6.18 (+5V)
unnamed: J6.13 (CEC), R2.2
unnamed: CMC4.2, J6.10 (CK+)
unnamed: CMC4.3, J6.12 (CK-)
unnamed: CMC3.2, J6.7 (D0+)
unnamed: CMC3.3, J6.9 (D0-)
unnamed: CMC2.2, J6.4 (D1+)
unnamed: CMC2.3, J6.6 (D1-)
unnamed: CMC1.2, J6.1 (D2+)
unnamed: CMC1.3, J6.3 (D2-)
unnamed: FB20.2, J6.19 (HPD)
unnamed: FB13.2, J6.15 (SCL)
unnamed: FB14.2, J6.16 (SDA)
unnamed: J6.14 (UTILITY), R3.2
unnamed: FB1.1, JP1.2 (C)
unnamed: CMC4.1, U24.7 (TMDS_C+)
unnamed: CMC4.4, U24.8 (TMDS_C-)
unnamed: CMC3.1, U24.5 (TMDS_D0+)
unnamed: CMC3.4, U24.6 (TMDS_D0-)
unnamed: CMC2.1, U24.3 (TMDS_D1+)
unnamed: CMC2.4, U24.4 (TMDS_D1-)
unnamed: CMC1.1, U24.1 (TMDS_D2+)
unnamed: CMC1.4, U24.2 (TMDS_D2-)
unnamed: U24.18 (VIDEO_CLK), X1.8 (OUT)
unnamed: TP2.1, U25.1 (CSB/GPIO1)
unnamed: C1.1, U25.7 (LAUXIN)
unnamed: C2.1, U25.15 (LHP)
unnamed: C13.1, U25.6 (RAUXIN)
unnamed: C3.1, U25.14 (RHP)
unnamed: C14.1, FB1.2, U25.13 (V_SPKR)
SYS_CLK: U24.29 (SYS_CLK), U25.28 (BCLK), U25.31 (MCLK); also elsewhere on the board
~RST: U24.28 (~RST); also elsewhere on the board
