# Repository andrastantos/anachron (continued)

## KiCad design boards/a1_micro_atx/a1_micro_atx.kicad_pcb (continued)

Parts:
C24, C25, C26: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C27, C28: 1uF; CP_Radial_D4.0mm_P2.00mm
C29: 4.7uF; CP_Radial_D4.0mm_P2.00mm
C30, C31: 220uF; CP_Radial_D7.5mm_P2.50mm
CMC1, CMC2, CMC3, CMC4: L_Ferrite_Coupled_Small; SCM2012FS
D6: 1N5817; D_DO-41_SOD81_P10.16mm_Horizontal
F1: 0.5A; Fuse_BelFuse_0ZRE0005FF_L8.3mm_W3.8mm
FB1, FB2, FB4, FB5, FB6, FB7, FB8, FB9: FerriteBead_Small; L_Axial_L7.0mm_D3.3mm_P2.54mm_Vertical_Fastron_MICC
FB3: FerriteBead_Small; L_Axial_L5.3mm_D2.2mm_P7.62mm_Horizontal_Vishay_IM-1
J8, J11: SJ1-3535NG-BE; CUI_SJ1-3535NG-BE; PARTREV 1.0
J9: Conn_01x02; PinHeader_1x04_P2.54mm_Vertical
J10: HDMI_A; HDMI_A_Molex_208658-1001_Horizontal
JP2: Jumper_3_Open; PinHeader_1x03_P2.54mm_Vertical
JP7: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
R10, R11, R14, R15: 47k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R12, R13: 220k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R16, R17: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
TP1: TestPoint_Alt; TestPoint_Plated_Hole_D2.0mm
U22: DISCO; DIP-40_W15.24mm_Socket
U23: A1_CODEC; DIP-32_W15.24mm_LongPads
X2: CXO_DIP14; Oscillator_DIP-14

Connections:
+5V: C24.1, C25.1, C26.1, D6.2 (A), JP2.1 (A), U22.40 (VCC), U23.32 (VCC_5), X2.1 (EN), X2.14 (Vcc); also elsewhere on the board
/CPU_~INT: U22.30 (~INT); also elsewhere on the board
/GFX/AUDIO_SDATA_IN: U22.22 (AUDIO_SDATA_IN), U23.29 (ADCOUT)
/GFX/AUDIO_SDATA_OUT: U22.21 (AUDIO_SDATA_OUT), U23.30 (DACIN)
/GFX/AUDIO_SFRM: U22.19 (AUDIO_SFRM), U23.27 (FS)
/GFX/CODEC_V3P3: JP2.3 (B), R12.1, R13.1, U23.5 (3P3_OUT)
/GFX/HP_DET: J11.4, R12.2, U23.24 (LLIN/GPIO2)
/GFX/LINE_IN_DET: J8.4, R13.2, U23.25 (RLIN/GPIO3)
/GFX/TMDS_CLK+: CMC4.1, U22.7 (TMDS_C+)
/GFX/TMDS_CLK-: CMC4.4, U22.8 (TMDS_C-)
/GFX/TMDS_D0+: CMC3.1, U22.5 (TMDS_D0+)
/GFX/TMDS_D0-: CMC3.4, U22.6 (TMDS_D0-)
/GFX/TMDS_D1+: CMC2.1, U22.3 (TMDS_D1+)
/GFX/TMDS_D1-: CMC2.4, U22.4 (TMDS_D1-)
/GFX/TMDS_D2+: CMC1.1, U22.1 (TMDS_D2+)
/GFX/TMDS_D2-: CMC1.4, U22.2 (TMDS_D2-)
/GFX_A0: U22.9 (A0); also elsewhere on the board
/GFX_A1: U22.10 (A1); also elsewhere on the board
/GFX_A2: U22.11 (A2); also elsewhere on the board
/GFX_A3: U22.12 (A3); also elsewhere on the board
/GFX_A4: U22.13 (A4); also elsewhere on the board
/GFX_A5: U22.14 (A5); also elsewhere on the board
/GFX_A6: U22.15 (A6); also elsewhere on the board
/GFX_A7: U22.16 (A7); also elsewhere on the board
/GFX_A8: U22.17 (A8); also elsewhere on the board
/GFX_D0: U22.32 (D0); also elsewhere on the board
/GFX_D1: U22.33 (D1); also elsewhere on the board
/GFX_D2: U22.34 (D2); also elsewhere on the board
/GFX_D3: U22.35 (D3); also elsewhere on the board
/GFX_D4: U22.36 (D4); also elsewhere on the board
/GFX_D5: U22.37 (D5); also elsewhere on the board
/GFX_D6: U22.38 (D6); also elsewhere on the board
/GFX_D7: U22.39 (D7); also elsewhere on the board
/GFX_~BUSY: U22.31 (~BUSY); also elsewhere on the board
/GFX_~CAS_0: U22.24 (~CAS_0); also elsewhere on the board
/GFX_~CAS_1: U22.25 (~CAS_1); also elsewhere on the board
/GFX_~RAS: U22.23 (~RAS_A); also elsewhere on the board
/GFX_~WE: U22.27 (~WE); also elsewhere on the board
/I2C_SCL: U23.3 (SDIO); also elsewhere on the board
/I2C_SDA: U23.2 (SCLK); also elsewhere on the board
/VIDEO_DDC_SCL: FB4.1; also elsewhere on the board
/VIDEO_DDC_SDA: FB6.1; also elsewhere on the board
/VIDEO_HPD: FB5.1; also elsewhere on the board
/~GFX_SEL: U22.26 (~REG_SEL); also elsewhere on the board
GND: C24.2, C25.2, C26.2, C29.2, J10.2 (D2S), J10.5 (D1S), J10.8 (D0S), J10.11 (CKS), J10.17 (GND), J10.SH, JP7.1 (A), R16.1, R17.1, U22.20 (GND), U23.4 (GND), X2.7 (GND); also elsewhere on the board
GNDA: J8.1, J11.1, JP7.2 (B), R10.2, R11.2, R14.2, R15.2, U23.10 (AGND), U23.16 (AGND), U23.17 (AGND), U23.23 (AGND), U23.26 (AGND)
unnamed: C27.2, FB1.2, R10.1
unnamed: C28.2, FB2.2, R11.1
unnamed: C30.2, FB7.2, R14.1
unnamed: C31.2, FB8.2, R15.1
unnamed: D6.1 (K), F1.2
unnamed: F1.1, FB9.2
unnamed: FB1.1, J8.2
unnamed: FB2.1, J8.3
unnamed: FB7.1, J11.2
unnamed: FB8.1, J11.3
unnamed: J9.1, J9.2, U23.12 (LSPKOUT)
unnamed: J9.3, J9.4, U23.11 (RSPKOUT)
unnamed: FB9.1, J10.18 (+5V)
unnamed: J10.13 (CEC), R16.2
unnamed: CMC4.2, J10.10 (CK+)
unnamed: CMC4.3, J10.12 (CK-)
unnamed: CMC3.2, J10.7 (D0+)
unnamed: CMC3.3, J10.9 (D0-)
unnamed: CMC2.2, J10.4 (D1+)
unnamed: CMC2.3, J10.6 (D1-)
unnamed: CMC1.2, J10.1 (D2+)
unnamed: CMC1.3, J10.3 (D2-)
unnamed: FB5.2, J10.19 (HPD)
unnamed: FB4.2, J10.15 (SCL)
unnamed: FB6.2, J10.16 (SDA)
unnamed: J10.14 (UTILITY), R17.2
unnamed: FB3.1, JP2.2 (C)
unnamed: U22.18 (VIDEO_CLK), X2.8 (OUT)
unnamed: TP1.1, U23.1 (CSB/GPIO1)
unnamed: C27.1, U23.7 (LAUXIN)
unnamed: C30.1, U23.15 (LHP)
unnamed: C28.1, U23.6 (RAUXIN)
unnamed: C31.1, U23.14 (RHP)
unnamed: C29.1, FB3.2, U23.13 (V_SPKR)
SYS_CLK: U22.29 (SYS_CLK), U23.28 (BCLK), U23.31 (MCLK); also elsewhere on the board
~RST: U22.28 (~RST); also elsewhere on the board

Notes on the sheet:
TMDS output is quite a bit dicey on UNIC. The power diodes add too much capacitive load and limit operations to maybe 250...300Mbps. That might be sufficient for VGA resolution but not for XGA.
GND and GNDA are tied inside CODEC

Schematic: mio.kicad_sch, Anachron uATX Main I/O Interfaces

Parts:
BT1: CR2032 holder; BatteryHolder_Keystone_103_1x20mm
C32, C33, C34, C35, C36, C37, C38, C66, C67: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
FB10, FB11, FB12, FB13, FB14: FerriteBead_Small; L_Axial_L7.0mm_D3.3mm_P2.54mm_Vertical_Fastron_MICC
J12: DE9_Plug; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_Hou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
J13: Micro_SD_Card; GCT_MEM2052-00-195-00-A_REVA
R18, R19: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R20, R21: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RN7, RN8, RN9: 10k; R_Array_SIP5
U24: MAX232; DIP-16_W7.62mm_LongPads
U25: MIO; DIP-40_W15.24mm_Socket
U26: DS1307+; DIP-8_W7.62mm
U29: L78L33ABZ-AP; TO-92_Inline
X3: 24MHz; Oscillator_DIP-14
Y1: 32768Hz; Crystal_AT310_D3.0mm_L10.0mm_Horizontal_1EP_style2

Connections:
+5V: C34.1, C36.1, C37.1, C38.1, C66.1, R21.2, RN7.1 (common), U24.16 (VCC), U25.40 (VCC), U26.8 (VCC), U29.3 (VI), X3.1 (EN), X3.14 (Vcc); also elsewhere on the board
+BATT: BT1.1 (+), U26.3 (VBAT)
/BUF_A0: U25.31 (A0); also elsewhere on the board
/BUF_D0: U25.32 (D0); also elsewhere on the board
/BUF_D1: U25.33 (D1); also elsewhere on the board
/BUF_D2: U25.34 (D2); also elsewhere on the board
/BUF_D3: U25.35 (D3); also elsewhere on the board
/BUF_D4: U25.36 (D4); also elsewhere on the board
/BUF_D5: U25.37 (D5); also elsewhere on the board
/BUF_D6: U25.38 (D6); also elsewhere on the board
/BUF_D7: U25.39 (D7); also elsewhere on the board
/BUF_~WE: U25.27 (~WE); also elsewhere on the board
/CPU_DRQ0: U25.23 (DRQ); also elsewhere on the board
/CPU_TC: U25.25 (~DMA_TC); also elsewhere on the board
/CPU_~DACK0: U25.24 (~DACK); also elsewhere on the board
/CPU_~INT: U25.30 (~INT); also elsewhere on the board
/I2C_SCL: RN7.5 (R4), U25.14 (PA7_I2CSCL2), U26.6 (SCL); also elsewhere on the board
/I2C_SDA: RN7.4 (R3), U25.13 (PA6_I2CSDA2), U26.5 (SDA); also elsewhere on the board
/I2C_~INT: R21.1, U25.1 (PC0_USBa_D+), U26.7 (SQW/OUT); also elsewhere on the board
/LAN_~INT: U25.4 (PC3_USBb_D-); also elsewhere on the board
/MIO/SD_CLK: J13.5 (CLK), RN8.4 (R3), U25.22 (PB5_SDclk)
/MIO/SD_CMD: J13.3 (CMD), RN8.5 (R4), U25.21 (PB4_SDcmd)
/MIO/SD_D0: J13.7 (DAT0), RN9.2 (R1), U25.15 (PB0_SDd0)
/MIO/SD_D1: J13.8 (DAT1), RN9.3 (R2), U25.16 (PB1_SDd1)
/MIO/SD_D2: J13.1 (DAT2), RN9.4 (R3), U25.17 (PB2_SDd2)
/MIO/SD_D3: J13.2 (DAT3/CD), RN9.5 (R4), U25.19 (PB3_SDd3)
/MIO/SER_CTS: R19.1, U25.10 (PA3_CTS_~SPICS)
/MIO/SER_RTS: U24.10 (T2IN), U25.9 (PA2_RTS_SPIMOSI)
/MIO/SER_RXD: R18.1, U25.8 (PA1_RXD)
/MIO/SER_TXD: U24.11 (T1IN), U25.7 (PA0_TXD)
/MIO/USB_CLK: U25.28 (USB_CLK), X3.8 (OUT); also elsewhere on the board
/MIO/VCC_SD: C67.1, J13.4 (VDD), R20.2, RN8.1 (common), RN9.1 (common), U29.1 (VO)
/USB_MAIN_D+: U25.5 (PC4_USBc_D+); also elsewhere on the board
/USB_MAIN_D-: U25.6 (PC5_USBc_D-); also elsewhere on the board
/VIDEO_DDC_SCL: RN7.3 (R2), U25.12 (PA5_SPICLK_I2CSCL1); also elsewhere on the board
/VIDEO_DDC_SDA: RN7.2 (R1), U25.11 (PA4_SPIMISO_I2CSDA1); also elsewhere on the board
/VIDEO_HPD: U25.3 (PC2_USBb_D+); also elsewhere on the board
/~MIO_SEL: U25.26 (~CS); also elsewhere on the board
GND: BT1.2 (-), C35.2, C36.2, C37.2, C38.2, C66.2, C67.2, J12.5, J13.6 (VSS), J13.10 (SHIELD), U24.15 (GND), U25.20 (GND), U26.4 (GND), U29.2 (GND), X3.7 (GND), Y1.3; also elsewhere on the board
unnamed: FB10.2, J12.4
unnamed: FB11.2, J12.3
unnamed: FB12.2, J12.7
unnamed: FB13.2, J12.2
unnamed: FB14.2, J12.8
unnamed: J13.9 (DET), R20.1, U25.2 (PC1_USBa_D-)
unnamed: C32.1, U24.1 (C1+)
unnamed: C32.2, U24.3 (C1-)
unnamed: C33.1, U24.4 (C2+)
unnamed: C33.2, U24.5 (C2-)
unnamed: FB13.1, U24.13 (R1IN)
unnamed: R18.2, U24.12 (R1OUT)
unnamed: FB14.1, U24.8 (R2IN)
unnamed: R19.2, U24.9 (R2OUT)
unnamed: FB11.1, U24.14 (T1OUT)
unnamed: FB12.1, U24.7 (T2OUT)
unnamed: C34.2, FB10.1, U24.2 (VS+)
unnamed: C35.1, U24.6 (VS-)
unnamed: U26.1 (X1), Y1.2
unnamed: U26.2 (X2), Y1.1
SYS_CLK: U25.18 (SYS_CLK); also elsewhere on the board
~RST: U25.29 (~RST); also elsewhere on the board

Notes on the sheet:
One could use the SIO10N268 ($10) which gives four UARTs and an FDD controller and it's in active production still. https://ww1.microchip.com/downloads/aemDocuments/documents/OTH/ProductDocuments/DataSheets/00001819A.pdf
TODO: check connector depth!
DTR: connected to +9V for mouse support

Board: 4 copper layers, 243.8 x 204.5 mm, 243 parts (0 on the bottom side), 353 nets.

## KiCad design boards/a1_sdcard/a1_sdcard.kicad_pcb

Parts:
J1, J2: Conn_01x05; PinHeader_1x07_P2.54mm_Vertical
J3: Micro_SD_Card; GCT_MEM2052-00-195-00-A_REVA

Connections:
/CLK: J1.4, J3.5 (CLK)
/CMD: J1.2, J3.3 (CMD)
/DAT0: J1.6, J3.7 (DAT0)
/DAT1: J1.7, J3.8 (DAT1)
/DAT2: J2.1, J3.1 (DAT2)
/DAT3/CD: J1.1, J3.2 (DAT3/CD)
/DET: J2.2, J3.9 (DET)
/VDD: J1.3, J3.4 (VDD)
GND: J1.5, J2.3, J3.6 (VSS), J3.10 (SHIELD)

Board: 2 copper layers, 21.6 x 17.8 mm, 3 parts (2 on the bottom side), 9 nets.

## KiCad design boards/a1_usbhub/a1_usbhub.kicad_pcb

Parts:
C1: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4, C5, C6, C9, C10, C11, C12, C13, C14, C15: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; not fitted
L1: 10uH; L_1008_2520Metric_Pad1.43x2.20mm_HandSolder
R1: 31.6k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4, R6, R7, R8, R9, R10: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 12k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SOCKET2: Conn_02x20_Counter_Clockwise; DIP-40_pin_header
U1: TXS0102DCT; SSOP-8_2.95x2.8mm_P0.65mm
U2: USB2517I-JZX; QFN50P900X900X100-65N
U3: AP62150Z6; SOT-563
U4, U5: TPS2054D; SOIC-16_3.9x9.9mm_P1.27mm
U6: 74LVC1G17; SOT-23-5_HandSoldering

Connections:
+3.3V: C4.1, C5.1, C6.1, C7.1, C8.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, L1.2, R1.1, R4.1, R6.1, R7.1, R8.1, R9.1, R10.1, U1.3 (VCCA), U1.6 (OE), U2.5 (VDDA33), U2.10 (VDDA33), U2.24 (VDD33CR), U2.46 (VDD33), U2.52 (VDDA33), U2.57 (VDDA33), U2.64 (VDD33PLL), U6.5 (VCC)
+5V: C1.1, SOCKET2.35, SOCKET2.36, SOCKET2.37, SOCKET2.38, SOCKET2.39, SOCKET2.40, U1.7 (VCCB), U3.1 (VIN), U3.5 (EN), U4.2 (IN1), U4.6 (IN2), U5.2 (IN1), U5.6 (IN2)
/CFG_SEL1: R7.2, SOCKET2.13, U2.42 (HS_IND/CFG_SEL1)
/CFG_SEL2: R6.2, SOCKET2.33, U2.13 (CFG_SEL2)
/PRTPWR1: U2.29 (PRTPWR1), U4.8 (EN4)
/PRTPWR2: U2.26 (PRTPWR2), U4.7 (EN3)
/PRTPWR3: U2.23 (PRTPWR3), U4.4 (EN2)
/PRTPWR4: U2.20 (PRTPWR4), U4.3 (EN1)
/PRTPWR5: U2.30 (PRTPWR5), U5.7 (EN3)
/PRTPWR6: U2.39 (PRTPWR6), U5.8 (EN4)
/PRTPWR7: U2.36 (PRTPWR7), U5.3 (EN1)
/SCL: SOCKET2.8, U1.1 (B2)
/SDA: SOCKET2.9, U1.8 (B1)
/USBDN1_DM: SOCKET2.23, U2.1 (USBDN1_DM/PRT_DIS_M1)
/USBDN1_DP: SOCKET2.24, U2.2 (USBDN1_DP/PRT_DIS_P1)
/USBDN2_DM: SOCKET2.25, U2.3 (USBDN2_DM/PRT_DIS_M2)
/USBDN2_DP: SOCKET2.26, U2.4 (USBDN2_DP/PRT_DIS_P2)
/USBDN3_DM: SOCKET2.27, U2.6 (USBDN3_DM/PRT_DIS_M3)
/USBDN3_DP: SOCKET2.28, U2.7 (USBDN3_DP/PRT_DIS_P3)
/USBDN4_DM: SOCKET2.29, U2.8 (USBDN4_DM/PRT_DIS_M4)
/USBDN4_DP: SOCKET2.30, U2.9 (USBDN4_DP/PRT_DIS_P4)
/USBDN5_DM: SOCKET2.31, U2.11 (USBDN5_DM/PRT_DIS_M5)
/USBDN5_DP: SOCKET2.32, U2.12 (USBDN5_DP/PRT_DIS_P5)
/USBDN6_DM: SOCKET2.14, U2.53 (USBDN6_DM/PRT_DIS_M6)
/USBDN6_DP: SOCKET2.15, U2.54 (USBDN6_DP/PRT_DIS_P6)
/USBDN7_DM: SOCKET2.16, U2.55 (USBDN7_DM/PRT_DIS_M7)
/USBDN7_DP: SOCKET2.17, U2.56 (USBDN7_DP/PRT_DIS_P7)
/USBUP_DM: SOCKET2.18, U2.58 (USBUP_DM)
/USBUP_DP: SOCKET2.19, U2.59 (USBUP_DP)
/VBUS1: SOCKET2.4, U4.10 (OUT4)
/VBUS2: SOCKET2.5, U4.11 (OUT3)
/VBUS3: SOCKET2.6, U4.14 (OUT2)
/VBUS4: SOCKET2.7, U4.15 (OUT1)
/VBUS5: SOCKET2.2, U5.11 (OUT3)
/VBUS6: SOCKET2.1, U5.10 (OUT4)
/VBUS7: SOCKET2.3, U5.15 (OUT1)
/XTAL1: SOCKET2.22, U2.61 (XTAL1/CLKIN)
/XTAL2: SOCKET2.21, U2.60 (XTAL2)
/~OCS_1: U2.28 (OCS1_N), U4.9 (~OC4)
/~OCS_2: U2.27 (OCS2_N), U4.12 (~OC3)
/~OCS_3: U2.22 (OCS3_N), U4.13 (~OC2)
/~OCS_4: U2.21 (OCS4_N), U4.16 (~OC1)
/~OCS_5: U2.35 (OCS5_N), U5.9 (~OC4)
/~OCS_6: U2.38 (OCS6_N), U5.12 (~OC3)
/~OCS_7: U2.37 (OCS7_N), U5.16 (~OC1)
/~RST: SOCKET2.12, U6.2
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, R2.2, R3.2, SOCKET2.10, SOCKET2.11, SOCKET2.20, SOCKET2.34, U1.2 (GND), U2.19 (TEST), U2.65 (VSS), U3.3 (GND), U4.1 (GND), U5.1 (GND), U5.5 (GND), U6.3 (GND)
unnamed: R9.2, U1.5 (A1), U2.40 (SDA/SMBDATA/NON_REM1)
unnamed: R10.2, U1.4 (A2), U2.41 (SCL/SMBCLK/CFG_SEL0)
unnamed: R3.1, U2.63 (RBIAS)
unnamed: U2.43 (RESET_N), U6.4
unnamed: R4.2, U2.45 (SUSP_IND/LOCAL_PWR/NON_REM0)
unnamed: R8.2, U2.44 (VBUS_DET)
unnamed: C9.1, U2.25 (VDD18)
unnamed: C3.1, U2.62 (VDD18PLL)
unnamed: C2.1, U3.4 (BST)
unnamed: R1.2, R2.1, U3.6 (FB)
unnamed: C2.2, L1.1, U3.2 (SW)

Notes on the sheet:
TODO: - Improve signal integrity - Widen power traces - Check all footprints, component values

Board: 2 copper layers, 49.4 x 15.2 mm, 32 parts (13 on the bottom side), 58 nets.

## KiCad design boards/a1_power/a1_power.kicad_pcb

Parts:
C1: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C4, C5: 22uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C6: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1, J2: Conn_01x05; PinHeader_1x07_P2.54mm_Vertical
L1: 1.5uH; HPC6045
R1: 221k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 30.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: AP62600SJ-7

Connections:
/EN: J2.6, U1.3 (EN)
/FSEL: J2.4, U1.5 (FSEL)
/GND: C2.2, C3.2, C4.2, C5.2, C6.2, J1.5, R2.2, U1.1 (PGND), U1.11 (GND)
/MODE: J2.5, U1.4 (MODE)
/PG: J2.3, U1.6 (PG)
/SS/TR: J2.7, U1.10 (SS/TR)
/VIN: C5.1, J1.6, J1.7, U1.2 (VIN)
/VOUT: C2.1, C3.1, C4.1, J1.1, J1.2, J1.3, J1.4, L1.2, R1.1
unnamed: C1.1, U1.7 (BST)
unnamed: R1.2, R2.1, U1.12 (FB)
unnamed: C1.2, L1.1, U1.8 (SW)
unnamed: C6.1, U1.9 (VCC)

Board: 2 copper layers, 16.5 x 17.8 mm, 12 parts (2 on the bottom side), 12 nets.
