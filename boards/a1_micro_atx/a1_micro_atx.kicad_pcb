# Repository andrastantos/anachron

## KiCad design boards/a1_micro_atx/a1_micro_atx.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C72, C73: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C7: 10nF; C_Disc_D4.7mm_W2.5mm_P5.00mm; not fitted
D1, D2: LED; LED_D5.0mm
D3: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
J1, J2, J3, J4, J22, J23, J24: Conn_01x01; MountingHole_4.3mm_M4_DIN965_Pad
J5: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J6: Jack-DC; BarrelJack_CUI_PJ-102AH_Horizontal
JP1, JP6: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3, R6, R7, R8, R9, R36: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R4, R5: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RN1, RN2, RN5: 10k; R_Array_SIP5
RN3, RN4: 10k; R_Array_SIP9
RN6: 10k; R_Array_SIP9; not fitted
SW2, SW4: SW_Push; PinHeader_1x02_P2.54mm_Vertical
SW3, SW5: SW_Push; SW_PUSH_6mm
U1: 74LS08; DIP-14_W7.62mm_LongPads
U2: 74LS86; DIP-14_W7.62mm_LongPads
U3: 74LS00; DIP-14_W7.62mm_LongPads
U4, U16, U17, U18: 74LS273; DIP-20_W7.62mm_LongPads
U5: 74LS574; DIP-20_W7.62mm_LongPads
U6: 74LS139; DIP-16_W7.62mm_LongPads
U7: 74LS14; DIP-14_W7.62mm_LongPads
U8: 74LS126; DIP-14_W7.62mm_LongPads
U9, U10, U13, U14, U15: 74AHCT245; DIP-20_W7.62mm_LongPads
U11: SST39SF040; PLCC-32_THT-Socket
U12: A1_POWER
U40: L78L05_TO92; TO-92_Inline
U43: ATtiny25-20P; DIP-8_W7.62mm_LongPads
X1: 8MHz; Oscillator_DIP-14

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C16.1, C17.1, C18.1, C19.1, D3.2 (A), J5.1, R2.1, R3.1, R5.1, R7.1, R9.1, RN1.1 (common), RN3.1 (common), RN5.1 (common), U1.14 (VCC), U2.4, U2.9, U2.12, U2.14 (VCC), U3.14 (VCC), U4.20 (VCC), U5.20 (VCC), U6.16 (VCC), U7.14 (VCC), U8.14 (VCC), U9.20 (VCC), U10.20 (VCC), U11.32 (VCC), U12.1 (VOUT), U12.2 (VOUT), U12.3 (VOUT), U12.4 (VOUT), U13.20 (VCC), U14.20 (VCC), U15.1 (A->B), U15.20 (VCC), U16.1 (~Mr), U16.20 (VCC), U17.1 (~Mr), U17.20 (VCC), U18.1 (~Mr), U18.20 (VCC), X1.1 (EN), X1.14 (Vcc); also elsewhere on the board
+5V_STB: C73.1, JP6.2 (B), R36.1, U40.1 (VO), U43.8 (VCC)
/BUF_A0: U3.2, U11.12 (A0), U15.8 (A6); also elsewhere on the board
/BUF_A1: U11.11 (A1), U16.19 (Q7); also elsewhere on the board
/BUF_A2: U11.10 (A2), U16.2 (Q0); also elsewhere on the board
/BUF_A3: U11.9 (A3), U16.16 (Q6); also elsewhere on the board
/BUF_A4: U11.8 (A4), U16.5 (Q1); also elsewhere on the board
/BUF_A5: U11.7 (A5), U16.15 (Q5); also elsewhere on the board
/BUF_A6: U11.6 (A6), U16.6 (Q2); also elsewhere on the board
/BUF_A7: U11.5 (A7), U16.12 (Q4); also elsewhere on the board
/BUF_A8: U11.27 (A8), U16.9 (Q3); also elsewhere on the board
/BUF_A9: U11.26 (A9), U15.3 (A1); also elsewhere on the board
/BUF_A10: U11.23 (A10), U15.4 (A2); also elsewhere on the board
/BUF_A11: U11.25 (A11), U15.5 (A3); also elsewhere on the board
/BUF_A12: U6.14 (A0), U11.4 (A12), U18.19 (Q7); also elsewhere on the board
/BUF_A13: U6.13 (A1), U11.28 (A13), U18.2 (Q0); also elsewhere on the board
/BUF_A14: U11.29 (A14), U18.16 (Q6); also elsewhere on the board
/BUF_A15: U11.3 (A15), U18.5 (Q1); also elsewhere on the board
/BUF_A16: U11.2 (A16), U18.15 (Q5); also elsewhere on the board
/BUF_A17: U11.30 (A17), U18.6 (Q2); also elsewhere on the board
/BUF_A18: U11.1 (A18), U18.12 (Q4); also elsewhere on the board
/BUF_A19: U18.9 (Q3); also elsewhere on the board
/BUF_A20: U17.19 (Q7); also elsewhere on the board
/BUF_A21: U6.2 (A0), U17.16 (Q6)
/BUF_A22: U6.3 (A1), U17.15 (Q5)
/BUF_CAS: U3.3, U3.4, U16.11 (Cp)
/BUF_D0: RN6.2 (R1), U4.8 (D3), U5.12 (Q7), U11.13 (D0), U14.7 (A5); also elsewhere on the board
/BUF_D1: RN6.3 (R2), U4.13 (D4), U5.13 (Q6), U11.14 (D1), U14.8 (A6); also elsewhere on the board
/BUF_D2: RN6.4 (R3), U4.7 (D2), U5.14 (Q5), U11.15 (D2), U14.9 (A7); also elsewhere on the board
/BUF_D3: RN6.5 (R4), U4.14 (D5), U5.15 (Q4), U11.17 (D3), U14.3 (A1); also elsewhere on the board
/BUF_D4: RN6.6 (R5), U4.4 (D1), U5.16 (Q3), U11.18 (D4), U14.2 (A0); also elsewhere on the board
/BUF_D5: RN6.7 (R6), U4.17 (D6), U5.17 (Q2), U11.19 (D5), U14.4 (A2); also elsewhere on the board
/BUF_D6: RN6.8 (R7), U4.3 (D0), U5.18 (Q1), U11.20 (D6), U14.5 (A3); also elsewhere on the board
/BUF_D7: RN6.9 (R8), U4.18 (D7), U5.19 (Q0), U11.21 (D7), U14.6 (A4); also elsewhere on the board
/BUF_DIR: U2.3, U7.9, U14.1 (A->B); also elsewhere on the board
/BUF_NREN: U2.8, U3.5, U7.10, U17.11 (Cp), U18.11 (Cp)
/BUF_TC: U15.2 (A0)
/BUF_~CAS: U3.1, U15.7 (A5)
/BUF_~EN: U1.3, U7.1, U14.19 (CE)
/BUF_~NREN: U2.10, U7.11, U15.9 (A7)
/BUF_~RD: U7.12, U11.24 (OE)
/BUF_~WE: U2.2, U7.13, U11.31 (PGM), U15.6 (A4); also elsewhere on the board
/CPU_A0: U9.2 (A0), U16.18 (D7), U18.18 (D7); also elsewhere on the board
/CPU_A1: U9.3 (A1), U16.3 (D0), U18.3 (D0); also elsewhere on the board
/CPU_A2: U9.4 (A2), U16.17 (D6), U18.17 (D6); also elsewhere on the board
/CPU_A3: U9.5 (A3), U16.4 (D1), U18.4 (D1); also elsewhere on the board
/CPU_A4: U9.6 (A4), U16.14 (D5), U18.14 (D5); also elsewhere on the board
/CPU_A5: U9.7 (A5), U16.7 (D2), U18.7 (D2); also elsewhere on the board
/CPU_A6: U9.8 (A6), U16.13 (D4), U18.13 (D4); also elsewhere on the board
/CPU_A7: U9.9 (A7), U16.8 (D3), U18.8 (D3); also elsewhere on the board
/CPU_A8: U10.3 (A1), U15.17 (B1), U17.18 (D7); also elsewhere on the board
/CPU_A9: U10.6 (A4), U15.16 (B2), U17.17 (D6); also elsewhere on the board
/CPU_A10: U10.7 (A5), U15.15 (B3), U17.14 (D5); also elsewhere on the board
/CPU_D0: U13.5 (A3), U14.13 (B5); also elsewhere on the board
/CPU_D1: U13.4 (A2), U14.12 (B6); also elsewhere on the board
/CPU_D2: U13.3 (A1), U14.11 (B7); also elsewhere on the board
/CPU_D3: U13.2 (A0), U14.17 (B1); also elsewhere on the board
/CPU_D4: U13.6 (A4), U14.18 (B0); also elsewhere on the board
/CPU_D5: U13.7 (A5), U14.16 (B2); also elsewhere on the board
/CPU_D6: U13.8 (A6), U14.15 (B3); also elsewhere on the board
/CPU_D7: U13.9 (A7), U14.14 (B4); also elsewhere on the board
/CPU_DACK: U2.1, U2.11; also elsewhere on the board
/CPU_DRQ0: RN2.5 (R4); also elsewhere on the board
/CPU_DRQ1: RN2.4 (R3); also elsewhere on the board
/CPU_DRQ2: RN2.3 (R2); also elsewhere on the board
/CPU_DRQ3: RN2.2 (R1); also elsewhere on the board
/CPU_TC: R1.1, U15.18 (B0); also elsewhere on the board
/CPU_~CAS_0: RN3.5 (R4), U10.5 (A3), U15.12 (B6); also elsewhere on the board
/CPU_~CAS_1: RN3.6 (R5), U10.4 (A2), U15.13 (B5); also elsewhere on the board
/CPU_~DACK0: RN1.5 (R4), U1.13; also elsewhere on the board
/CPU_~DACK1: RN1.4 (R3), U1.12; also elsewhere on the board
/CPU_~DACK2: RN1.3 (R2), U1.10; also elsewhere on the board
/CPU_~DACK3: RN1.2 (R1), U1.9; also elsewhere on the board
/CPU_~DACK: U1.2, U1.6, U2.13; also elsewhere on the board
/CPU_~INT: R2.2, U8.6; also elsewhere on the board
/CPU_~NREN: RN3.7 (R6), U1.1, U15.11 (B7); also elsewhere on the board
/CPU_~RAS_A: RN3.3 (R2); also elsewhere on the board
/CPU_~RAS_B: RN3.4 (R3), U10.8 (A6); also elsewhere on the board
/CPU_~WAIT: RN3.9 (R8), U8.3; also elsewhere on the board
/CPU_~WE: RN3.8 (R7), U10.2 (A0), U15.14 (B4); also elsewhere on the board
/GFX_A0: U9.18 (B0); also elsewhere on the board
/GFX_A1: U9.17 (B1); also elsewhere on the board
/GFX_A2: U9.16 (B2); also elsewhere on the board
/GFX_A3: U9.15 (B3); also elsewhere on the board
/GFX_A4: U9.14 (B4); also elsewhere on the board
/GFX_A5: U9.13 (B5); also elsewhere on the board
/GFX_A6: U9.12 (B6); also elsewhere on the board
/GFX_A7: U9.11 (B7); also elsewhere on the board
/GFX_A8: U10.17 (B1); also elsewhere on the board
/GFX_A9: U8.8, U10.14 (B4); also elsewhere on the board
/GFX_A10: U8.11, U10.13 (B5); also elsewhere on the board
/GFX_BUSY: U2.6, U3.13, U8.10, U8.13, U9.19 (CE), U10.19 (CE), U13.19 (CE)
/GFX_D0: U13.15 (B3); also elsewhere on the board
/GFX_D1: U13.16 (B2); also elsewhere on the board
/GFX_D2: U13.17 (B1); also elsewhere on the board
/GFX_D3: U13.18 (B0); also elsewhere on the board
/GFX_D4: U13.14 (B4); also elsewhere on the board
/GFX_D5: U13.13 (B5); also elsewhere on the board
/GFX_D6: U13.12 (B6); also elsewhere on the board
/GFX_D7: U13.11 (B7); also elsewhere on the board
/GFX_~BUSY: R3.2, U2.5; also elsewhere on the board
/GFX_~CAS_0: RN5.3 (R2), U10.15 (B3); also elsewhere on the board
/GFX_~CAS_1: RN5.4 (R3), U10.16 (B2); also elsewhere on the board
/GFX_~RAS: RN5.2 (R1), U10.12 (B6); also elsewhere on the board
/GFX_~WE: RN5.5 (R4), U10.18 (B0); also elsewhere on the board
/I2C_SCL: U43.7 (PB2); also elsewhere on the board
/I2C_SDA: U43.5 (AREF/PB0); also elsewhere on the board
/I2C_~INT: U43.6 (PB1); also elsewhere on the board
/ISA/~INT: R9.2, U8.4; also elsewhere on the board
/ISA_CH_CK: RN4.8 (R7), U5.3 (D1); also elsewhere on the board
/ISA_IRQ2: RN4.7 (R6), U5.4 (D2); also elsewhere on the board
/ISA_IRQ3: RN4.6 (R5), U5.5 (D3); also elsewhere on the board
/ISA_IRQ4: RN4.5 (R4), U5.6 (D4); also elsewhere on the board
/ISA_IRQ5: RN4.4 (R3), U5.7 (D5); also elsewhere on the board
/ISA_IRQ6: RN4.3 (R2), U5.8 (D6); also elsewhere on the board
/ISA_IRQ7: RN4.2 (R1), U5.9 (D7); also elsewhere on the board
/PG: JP1.1 (A), U12.12 (PG)
/PWR_IN: C72.1, D3.1 (K), J6.1, U12.6 (VIN), U12.7 (VIN), U40.3 (VI)
/PWR_ON: JP6.1 (A), R6.1, U12.9 (EN), U43.2 (XTAL1/PB3)
/~GFX_SEL: U3.9, U6.12 (O0); also elsewhere on the board
/~IO_SEL: U6.6 (O2), U6.15 (E)
/~ISA_SEL: U6.5 (O1); also elsewhere on the board
/~LAN_SEL: U6.7 (O3); also elsewhere on the board
/~MIO_SEL: U6.9 (O3); also elsewhere on the board
/~MRST: JP1.2 (B), R7.2, SW2.2, SW3.2, U7.3
/~NR_DECODE_EN: U3.6, U6.1 (E)
/~ROM0_SEL: U6.4 (O0), U11.22 (CE)
/~SYS_GPIO1_SEL: U4.11 (Cp), U6.11 (O1)
/~SYS_GPIO2_SEL: U5.1 (OE), U6.10 (O2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C72.2, C73.2, D1.1 (K), D2.1 (K), J1.1, J2.1, J3.1, J4.1, J6.2, J22.1, J23.1, J24.1, R1.2, R6.2, RN2.1 (common), RN4.1 (common), RN6.1 (common), SW2.1, SW3.1, SW4.1, SW5.1, U1.7 (GND), U2.7 (GND), U3.7 (GND), U4.10 (GND), U5.10 (GND), U6.8 (GND), U7.7 (GND), U8.2, U8.5, U8.7 (GND), U9.1 (A->B), U9.10 (GND), U10.1 (A->B), U10.10 (GND), U11.16 (GND), U12.5 (GND), U13.10 (GND), U14.10 (GND), U15.10 (GND), U15.19 (CE), U16.10 (GND), U17.10 (GND), U18.10 (GND), U40.2 (GND), U43.4 (GND), X1.7 (GND); also elsewhere on the board
unnamed: C15.1, R8.2, U7.5
unnamed: D1.2 (A), R4.2
unnamed: D2.2 (A), R5.2
unnamed: J5.2, RN4.9 (R8), U5.2 (D0)
unnamed: R8.1, U7.4
unnamed: U1.5, U1.8
unnamed: U1.4, U1.11
unnamed: U3.10, U7.2
unnamed: U3.11, U8.1
unnamed: U3.8, U3.12
unnamed: U4.2 (Q0), U8.9
unnamed: R4.1, U4.9 (Q3)
unnamed: U4.19 (Q7), U8.12
unnamed: C7.1, U12.8 (SS/TR)
unnamed: U7.8, U13.1 (A->B)
unnamed: R36.2, SW4.2, SW5.2, U43.1 (~RESET/PB5)
SYS_CLK: X1.8 (OUT); also elsewhere on the board
~RST: U4.1 (~Mr), U7.6, U43.3 (XTAL2/PB4); also elsewhere on the board

Notes on the sheet:
Primary power
Reset generation
Always on domain
I/O
Mounting holes
For ~{GFX_SEL} cycles: ~{WAIT} is driven; GFX_~{BUSY} must be high.
For ~{NRAM} cycles: ~{WAIT} is not driven; GFX_~{BUSY} must be high.
Data is captured on the falling edge of nWE | nCAS by the DRAM. Thus, buffering either of those will not cause write-setup violations. At the same time, read responses are delayed, but that can be handled by slowing the clock down. So, all in all, we can buffer control and address signals to the DR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
Something faster than AHCT would very nice.
BUF_NREN
PWR SWITCH
TODO: consider replacing '273-s with '574 ones. They seem to have a more forgiving pinout.
POWER BTN
PWR LED
For ~{RAS_x} cycles: ~{WAIT} is driven
ACTIVITY LED
TODO: check all bypass capacitors: do we have enough for everybody?
RESET BTN
We disable GFX~{BUSY} propagation to CPU_~{WAIT} when we do I/O or DMA cycles. This allows for peripherals to generate their own wait-states without the GFX chip interfering all the time.
For ~{DACK} cycles: ~{WAIT} is not driven; GFX_~{BUSY} must be high.
BOOT SELECT

Parts:
C39, C40: 22pF; C_Disc_D3.4mm_W2.1mm_P2.50mm
C41, C42: 0.1uF; C_Disc_D3.4mm_W2.1mm_P2.50mm
C43: 10u; CP_Radial_D4.0mm_P2.00mm
J14: ARJM11D7-009-AB-EW2
R22: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R23, R24: 220; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R25, R26, R27, R28: 49.9; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
U27: KSZ8851-11MLL; DIP-32_W15.24mm_LongPads
Y2: 25MHz; Crystal_HC49-U_Vertical

Connections:
+5V: R22.2, U27.32 (VCC); also elsewhere on the board
/BUF_A0: U27.15 (CMD); also elsewhere on the board
/BUF_D0: U27.9 (D7); also elsewhere on the board
/BUF_D1: U27.8 (D6); also elsewhere on the board
/BUF_D2: U27.7 (D5); also elsewhere on the board
/BUF_D3: U27.6 (D4); also elsewhere on the board
/BUF_D4: U27.5 (D3); also elsewhere on the board
/BUF_D5: U27.4 (D2); also elsewhere on the board
/BUF_D6: U27.3 (D1); also elsewhere on the board
/BUF_D7: U27.2 (D0); also elsewhere on the board
/BUF_~WE: U27.14 (~WE); also elsewhere on the board
/ETH/ETH_RX+: J14.R3 (RD+), R25.2, U27.26 (RXP1)
/ETH/ETH_RX-: J14.R6 (RD-), R26.2, U27.27 (RXM1)
/ETH/ETH_TX+: J14.R1 (TD+), R27.2, U27.29 (TXP1)
/ETH/ETH_TX-: J14.R2 (TD-), R28.2, U27.30 (TXM1)
/LAN_~INT: R22.1, U27.13 (~INTR); also elsewhere on the board
/~LAN_SEL: U27.17 (~CS); also elsewhere on the board
GND: C39.2, C40.2, C41.2, C42.2, C43.2, J14.R8, J14.SH, U27.16 (GND), U27.19 (GND), U27.20 (GND), U27.24 (GND), U27.25 (GND), U27.28 (GND), U27.31 (GND); also elsewhere on the board
unnamed: C41.1, R25.1, R26.1
unnamed: C42.1, R27.1, R28.1
unnamed: J14.L1, R23.2
unnamed: J14.L3, R24.2
unnamed: C43.1, J14.R4 (TCT), J14.R5 (RCT), U27.22 (VDD3P3_A)
unnamed: R23.1, U27.11 (P1LED0)
unnamed: R24.1, U27.10 (P1LED1)
unnamed: J14.L2, J14.L4, U27.1 (V3P3)
unnamed: C40.1, U27.21 (XTAL1), Y2.2
unnamed: C39.1, U27.23 (XTAL2), Y2.1
~RST: U27.18 (~RST); also elsewhere on the board
