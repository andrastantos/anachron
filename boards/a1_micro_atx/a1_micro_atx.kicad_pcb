# Repository andrastantos/anachron (continued)

## KiCad design boards/a1_mega/a1_mega.kicad_pcb

Parts:
C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C68: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
J16, J17, J18, J19, J20, J21, J22, J23, J24: Conn_01x01; MountingHole_4.3mm_M4_DIN965_Pad
JP3: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
R10, R11, R27: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RN1, RN14: 10k; R_Array_SIP9
RN2, RN12, RN13: 10k; R_Array_SIP5
U1: 74LS139; DIP-16_W7.62mm_LongPads
U2, U3: 74LS08; DIP-14_W7.62mm_LongPads
U4: 74LS32; DIP-14_W7.62mm_LongPads
U5, U16, U17: 74LS273; DIP-20_W7.62mm_LongPads
U6: 74LS574; DIP-20_W7.62mm_LongPads
U7: 74LS04; DIP-14_W7.62mm_LongPads
U8: 74LS27; DIP-14_W7.62mm_LongPads
U9: 74LS86; DIP-14_W7.62mm_LongPads
U10, U11, U12, U13, U14, U15: 74AHCT245; DIP-20_W7.62mm_LongPads
U18: 74LS138; DIP-16_W7.62mm_LongPads
U22: 74LS125; DIP-14_W7.62mm_LongPads
U27, U37: SST39SF040; PLCC-32_THT-Socket
U33: 74LS00; DIP-14_W7.62mm_LongPads
X3: 8MHz; Oscillator_DIP-14

Connections:
+5V: C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C68.1, R10.1, RN2.1 (common), RN13.1 (common), RN14.1 (common), U1.16 (VCC), U2.14 (VCC), U3.14 (VCC), U4.14 (VCC), U5.20 (VCC), U6.20 (VCC), U7.14 (VCC), U8.14 (VCC), U9.12, U9.14 (VCC), U10.20 (VCC), U11.2 (A0), U11.3 (A1), U11.4 (A2), U11.16 (B2), U11.17 (B1), U11.18 (B0), U11.20 (VCC), U12.20 (VCC), U13.20 (VCC), U14.1 (A->B), U14.20 (VCC), U15.1 (A->B), U15.20 (VCC), U16.1 (~Mr), U16.20 (VCC), U17.1 (~Mr), U17.20 (VCC), U18.16 (VCC), U27.32 (VCC), U33.9, U33.12, U33.14 (VCC), U37.32 (VCC), X3.1 (EN), X3.14 (Vcc); also elsewhere on the board
/BUF_A0: U14.4 (A2), U27.12 (A0), U33.2, U37.12 (A0); also elsewhere on the board
/BUF_A1: U15.9 (A7), U27.11 (A1), U37.11 (A1)
/BUF_A2: U15.8 (A6), U27.10 (A2), U37.10 (A2)
/BUF_A3: U15.7 (A5), U27.9 (A3), U37.9 (A3)
/BUF_A4: U15.6 (A4), U27.8 (A4), U37.8 (A4)
/BUF_A5: U15.5 (A3), U27.7 (A5), U37.7 (A5)
/BUF_A6: U15.4 (A2), U27.6 (A6), U37.6 (A6)
/BUF_A7: U15.3 (A1), U27.5 (A7), U37.5 (A7)
/BUF_A8: U15.2 (A0), U27.27 (A8), U37.27 (A8)
/BUF_A9: U14.9 (A7), U27.26 (A9), U37.26 (A9)
/BUF_A10: U14.8 (A6), U27.23 (A10), U37.23 (A10)
/BUF_A11: U14.7 (A5), U27.25 (A11), U37.25 (A11)
/BUF_A12: U17.19 (Q7), U27.4 (A12), U37.4 (A12)
/BUF_A13: U17.16 (Q6), U27.28 (A13), U37.28 (A13)
/BUF_A14: U17.15 (Q5), U27.29 (A14), U37.29 (A14)
/BUF_A15: U17.12 (Q4), U27.3 (A15), U37.3 (A15)
/BUF_A16: U17.9 (Q3), U18.1 (A0), U27.2 (A16), U37.2 (A16)
/BUF_A17: U17.6 (Q2), U18.2 (A1), U27.30 (A17), U37.30 (A17)
/BUF_A18: U17.5 (Q1), U18.3 (A2), U27.1 (A18), U37.1 (A18)
/BUF_A19: U17.2 (Q0), U18.6 (E3)
/BUF_A20: U16.19 (Q7), U18.4 (E1)
/BUF_A21: U1.2 (A0), U16.16 (Q6)
/BUF_A22: U1.3 (A1), U16.15 (Q5)
/BUF_CAS: U33.3, U33.4
/BUF_D0: RN1.2 (R1), U5.3 (D0), U6.12 (Q7), U13.9 (A7), U27.13 (D0), U37.13 (D0); also elsewhere on the board
/BUF_D1: RN1.3 (R2), U5.4 (D1), U6.13 (Q6), U13.8 (A6), U27.14 (D1), U37.14 (D1); also elsewhere on the board
/BUF_D2: RN1.4 (R3), U5.7 (D2), U6.14 (Q5), U13.7 (A5), U27.15 (D2), U37.15 (D2); also elsewhere on the board
/BUF_D3: RN1.5 (R4), U5.8 (D3), U6.15 (Q4), U13.6 (A4), U27.17 (D3), U37.17 (D3); also elsewhere on the board
/BUF_D4: RN1.6 (R5), U5.13 (D4), U6.16 (Q3), U13.5 (A3), U27.18 (D4), U37.18 (D4); also elsewhere on the board
/BUF_D5: RN1.7 (R6), U5.14 (D5), U6.17 (Q2), U13.4 (A2), U27.19 (D5), U37.19 (D5); also elsewhere on the board
/BUF_D6: RN1.8 (R7), U5.17 (D6), U6.18 (Q1), U13.3 (A1), U27.20 (D6), U37.20 (D6); also elsewhere on the board
/BUF_D7: RN1.9 (R8), U5.18 (D7), U6.19 (Q0), U13.2 (A0), U27.21 (D7), U37.21 (D7); also elsewhere on the board
/BUF_DIR: U9.3, U13.1 (A->B)
/BUF_NREN: U7.4, U16.11 (Cp), U17.11 (Cp), U33.5, U33.8
/BUF_TC: U14.5 (A3); also elsewhere on the board
/BUF_nEN: U3.8, U13.19 (CE)
/BUF_~CAS: U14.3 (A1), U33.1
/BUF_~NREN: U7.3, U14.6 (A4), U33.10
/BUF_~RD: U7.10, U27.24 (OE), U37.24 (OE)
/BUF_~WE: U7.11, U9.2, U14.2 (A0), U27.31 (PGM), U37.31 (PGM); also elsewhere on the board
/CPU_A1: U10.3 (A1), U15.12 (B6), U17.17 (D6)
/CPU_A2: U10.4 (A2), U15.13 (B5), U17.14 (D5)
/CPU_A3: U10.5 (A3), U15.14 (B4), U17.13 (D4)
/CPU_A4: U10.6 (A4), U15.15 (B3), U17.8 (D3)
/CPU_A5: U10.7 (A5), U15.16 (B2), U17.7 (D2)
/CPU_A6: U10.8 (A6), U15.17 (B1), U17.4 (D1)
/CPU_A7: U10.9 (A7), U15.18 (B0), U17.3 (D0)
/CPU_A8: U11.9 (A7), U14.11 (B7), U16.18 (D7)
/CPU_A9: U14.12 (B6), U16.17 (D6)
/CPU_A10: U14.13 (B5), U16.14 (D5)
/CPU_DACK: U9.1, U9.11; also elsewhere on the board
/CPU_DRQ0: RN12.5 (R4); also elsewhere on the board
/CPU_DRQ1: RN12.4 (R3); also elsewhere on the board
/CPU_DRQ2: RN12.3 (R2); also elsewhere on the board
/CPU_DRQ3: RN12.2 (R1); also elsewhere on the board
/CPU_TC: R11.1, U14.15 (B3); also elsewhere on the board
/CPU_~CAS_0: RN14.5 (R4), U11.7 (A5), U14.16 (B2); also elsewhere on the board
/CPU_~CAS_1: RN14.6 (R5), U11.6 (A4), U14.17 (B1); also elsewhere on the board
/CPU_~DACK0: RN13.5 (R4), U3.1; also elsewhere on the board
/CPU_~DACK1: RN13.4 (R3), U3.2; also elsewhere on the board
/CPU_~DACK2: RN13.3 (R2), U3.12; also elsewhere on the board
/CPU_~DACK3: RN13.2 (R1), U3.13; also elsewhere on the board
/CPU_~DACK: U3.6, U3.10, U9.13
/CPU_~INT: R10.2, U22.11; also elsewhere on the board
/CPU_~NREN: RN14.2 (R1), U3.9, U14.14 (B4); also elsewhere on the board
/CPU_~RAS_A: RN14.3 (R2); also elsewhere on the board
/CPU_~RAS_B: RN14.4 (R3), U11.8 (A6); also elsewhere on the board
/CPU_~WE: RN14.7 (R6), U11.5 (A3), U14.18 (B0), U33.13; also elsewhere on the board
/GFX_A0: U10.18 (B0); also elsewhere on the board
/GFX_A1: U10.17 (B1); also elsewhere on the board
/GFX_A2: U10.16 (B2); also elsewhere on the board
/GFX_A3: U10.15 (B3); also elsewhere on the board
/GFX_A4: U10.14 (B4); also elsewhere on the board
/GFX_A5: U10.13 (B5); also elsewhere on the board
/GFX_A6: U10.12 (B6); also elsewhere on the board
/GFX_A7: U10.11 (B7); also elsewhere on the board
/GFX_A8: U11.11 (B7); also elsewhere on the board
/GFX_D0: U12.18 (B0); also elsewhere on the board
/GFX_D1: U12.17 (B1); also elsewhere on the board
/GFX_D2: U12.16 (B2); also elsewhere on the board
/GFX_D3: U12.15 (B3); also elsewhere on the board
/GFX_D4: U12.14 (B4); also elsewhere on the board
/GFX_D5: U12.13 (B5); also elsewhere on the board
/GFX_D6: U12.12 (B6); also elsewhere on the board
/GFX_D7: U12.11 (B7); also elsewhere on the board
/GFX_~CAS_0: RN2.3 (R2), U11.13 (B5); also elsewhere on the board
/GFX_~CAS_1: RN2.4 (R3), U11.14 (B4); also elsewhere on the board
/GFX_~RAS: RN2.2 (R1), U11.12 (B6); also elsewhere on the board
/GFX_~WE: RN2.5 (R4), U11.15 (B3); also elsewhere on the board
/ISA_IRQ2: U6.9 (D7), U8.13; also elsewhere on the board
/ISA_IRQ3: U6.8 (D6), U8.2; also elsewhere on the board
/ISA_IRQ4: U6.7 (D5), U8.1; also elsewhere on the board
/ISA_IRQ5: U6.6 (D4), U8.5; also elsewhere on the board
/ISA_IRQ6: U6.5 (D3), U8.4; also elsewhere on the board
/ISA_IRQ7: U6.4 (D2), U8.3; also elsewhere on the board
/Power/I2C_EN: U5.19 (Q7); also elsewhere on the board
/Power/PWR_OFF: JP3.1 (A), R27.1; also elsewhere on the board
/nNR_DECODE_EN: U1.1 (E), U33.6
/~GFX_SEL: U18.15 (O0); also elsewhere on the board
/~IO_SEL: U1.6 (O2), U18.5 (E2)
/~ISA_DMA1_EN: U5.2 (Q0); also elsewhere on the board
/~ISA_DMA2_EN: U5.5 (Q1); also elsewhere on the board
/~ISA_IO_CH_CK: U2.1, U6.3 (D1); also elsewhere on the board
/~ISA_SEL: U1.7 (O3); also elsewhere on the board
/~LAN_IRQ: U2.2, U6.2 (D0); also elsewhere on the board
/~LAN_SEL: U18.11 (O4); also elsewhere on the board
/~MIO_SEL: U18.12 (O3); also elsewhere on the board
/~ROM0_SEL: U1.4 (O0), U27.22 (CE), U37.22 (CE)
/~ROM1_SEL: U1.5 (O1)
/~SYS_GPIO1_SEL: U5.11 (Cp), U18.14 (O1)
/~SYS_GPIO2_SEL: U6.1 (OE), U18.13 (O2)
GND: C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C68.2, R11.2, R27.2, RN1.1 (common), RN12.1 (common), U1.8 (GND), U2.7 (GND), U3.7 (GND), U4.7 (GND), U5.10 (GND), U6.10 (GND), U7.7 (GND), U8.7 (GND), U9.7 (GND), U10.1 (A->B), U10.10 (GND), U11.1 (A->B), U11.10 (GND), U12.10 (GND), U13.10 (GND), U14.10 (GND), U14.19 (CE), U15.10 (GND), U15.19 (CE), U16.10 (GND), U17.10 (GND), U18.8 (GND), U22.12, U27.16 (GND), U33.7 (GND), U37.16 (GND), X3.7 (GND); also elsewhere on the board
unnamed: JP3.2 (B), U5.16 (Q6)
unnamed: U2.4, U8.6
unnamed: U2.5, U8.12
unnamed: U2.11, U22.13
unnamed: U2.6, U2.12
unnamed: U2.3, U2.13
unnamed: U3.3, U3.4
unnamed: U3.5, U3.11
unnamed: U7.2, U10.19 (CE), U11.19 (CE), U12.19 (CE)
unnamed: U12.1 (A->B), U33.11
SYS_CLK: X3.8 (OUT); also elsewhere on the board
~RST: U5.1 (~Mr); also elsewhere on the board

Notes on the sheet:
Data is captured on the falling edge of nWE | nCAS by the DRAM. Thus, buffering either of those will not cause write-setup violations. At the same time, read responses are delayed, but that can be handled by slowing the clock down. So, all in all, we can buffer control and address signals to the DR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
Something faster than AHCT would very nice.
BUF_NREN
WiFi is difficult: The ESP32-based modules are cheap and available, but they really would like to see a UART interface (with an AT command set), which means very low data-rates. I think I'll punt on WiFi for now: it's wired LAN through something something Microchip.
One could also use the SIO10N268 ($10) which gives for UARTs and an FDD controller and it's in active production still. https://ww1.microchip.com/downloads/aemDocuments/documents/OTH/ProductDocuments/DataSheets/00001819A.pdf Or the FDC37C78 ($11), which is just a FDD controller and is not recommend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

Parts:
BT1: CR2032 holder; BatteryHolder_Keystone_103_1x20mm
C23, C24: 22pF; C_Disc_D3.4mm_W2.1mm_P2.50mm
C67: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
D1, D2: 1N5711; D_DO-35_SOD27_P7.62mm_Horizontal
J15: ATX-24; TE_1-1775099-3
Q1: 2N7000; TO-92_Inline
R22: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal; not fitted
R23, R24, R25, R26, R29: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
SW1, SW3: SW_Push; PinHeader_1x02_P2.54mm_Vertical
SW2, SW4: SW_Push; SW_PUSH_6mm
U2: 74LS08; DIP-14_W7.62mm_LongPads
U7: 74LS04; DIP-14_W7.62mm_LongPads
U38: ATtiny24-20P; DIP-14_W7.62mm
Y3: 32768Hz; Crystal_AT310_D3.0mm_L10.0mm_Horizontal_1EP_style2

Connections:
+5V: J15.4 (+5V), J15.6 (+5V), J15.21 (+5V), J15.22 (+5V), J15.23 (+5V), R23.1, R29.1, U38.8 (PA5); also elsewhere on the board
+12V: J15.10 (+12V), J15.11 (+12V); also elsewhere on the board
+BATT: BT1.1 (+), D2.2 (A); also elsewhere on the board
-12V: J15.14 (-12V); also elsewhere on the board
/I2C_SCL: U38.9 (PA4); also elsewhere on the board
/I2C_SDA: U38.7 (PA6); also elsewhere on the board
/Power/I2C_EN: R29.2, U38.13 (AREF/PA0); also elsewhere on the board
/Power/PWR_OFF: U38.11 (PA2); also elsewhere on the board
/Power/PWR_ON: Q1.2 (G), R25.1, U38.6 (PA7)
/Power/V5MCU: C67.1, D1.1 (K), D2.1 (K), R26.1, U38.1 (VCC)
/Power/V5STB: D1.2 (A), J15.9 (+5VSB), R22.1
/~RTC_INT: U38.12 (PA1); also elsewhere on the board
GND: BT1.2 (-), C23.2, C24.2, C67.2, J15.3 (GND), J15.5 (GND), J15.7 (GND), J15.15 (GND), J15.17 (GND), J15.18 (GND), J15.19 (GND), J15.24 (GND), Q1.1 (S), R24.2, R25.2, SW1.1, SW2.1, SW3.1, SW4.1, U38.14 (GND); also elsewhere on the board
unnamed: J15.1 (+3.3V), J15.2 (+3.3V), J15.12 (+3.3V), J15.13 (+3.3V)
unnamed: J15.16 (PS_ON#), Q1.3 (D)
unnamed: J15.8 (PWR_OK), U7.13
unnamed: R23.2, SW1.2, SW2.2, U2.9
unnamed: U2.10, U7.12
unnamed: C24.1, U38.2 (XTAL1/PB0), Y3.1
unnamed: C23.1, U38.3 (XTAL2/PB1), Y3.2
unnamed: R22.2, R26.2, SW3.2, SW4.2, U38.4 (~RESET/PB3)
~RST: R24.1, U2.8, U38.10 (PA3); also elsewhere on the board

Notes on the sheet:
Switch pins double as debug-wire programming connector. ... which is nice.
TODO: make sure pins are used in a sane way with regards to pin-mux options.
I2C pull-ups are inactive when power is off. PA5 and PA3 needs monitoring and all I2C transactions are to be ignored when either pin is low. I2C is also very slow (32kHz clock!) I2C_EN must be active (high) in order for I2C to work. This enables other peripherals to work at higher rates.
